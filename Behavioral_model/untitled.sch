v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} -50 50 0 0 {name=p1 lab=xxx}
