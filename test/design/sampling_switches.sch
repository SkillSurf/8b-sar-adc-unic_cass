v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {lab_pin.sym} -390 -90 0 0 {name=p82 sig_type=std_logic lab=smpl}
C {lab_pin.sym} -280 -120 1 0 {name=p85 sig_type=std_logic lab=vcm}
C {iopin.sym} -10 -200 2 0 {name=p44 lab=com_x}
C {lab_pin.sym} -350 0 3 0 {name=p43 sig_type=std_logic lab=com_x}
C {lab_pin.sym} -250 -30 2 0 {name=p68 sig_type=std_logic lab=sub_sample}
C {final/tg_final.sym} -240 150 0 0 {name=x1}
C {ipin.sym} -20 -320 0 0 {name=p63 lab=smpl


}
C {ipin.sym} -20 -290 0 0 {name=p64 lab=smpl_out_n



}
C {ipin.sym} -20 -260 0 0 {name=p79 lab=smpl_n_d12


}
C {ipin.sym} -20 -230 0 0 {name=p80 lab=smpl_n_d12_out_n



}
C {iopin.sym} -130 -350 0 0 {name=p2 lab=sub_sample}
C {lab_pin.sym} -250 -50 2 0 {name=p3 sig_type=std_logic lab=smpl_out_n}
C {iopin.sym} -240 -230 0 0 {name=p48 lab=vdd
}
C {lab_pin.sym} -390 -70 0 0 {name=p4 sig_type=std_logic lab=vdd}
C {ipin.sym} -200 -290 0 0 {name=p5 lab=vcm
}
C {ipin.sym} -200 -320 0 0 {name=p6 lab=vref
}
C {final/tg_final.sym} 80 150 0 0 {name=x2}
C {ipin.sym} -200 -350 0 0 {name=p7 lab=vin_x
}
C {lab_pin.sym} 40 -120 1 0 {name=p8 sig_type=std_logic lab=vin_x}
C {lab_pin.sym} -30 0 3 0 {name=p9 sig_type=std_logic lab=Vin}
C {final/tg_final.sym} 390 150 0 0 {name=x3}
C {lab_pin.sym} -70 -90 2 1 {name=p10 sig_type=std_logic lab=smpl}
C {lab_pin.sym} -70 -70 0 0 {name=p11 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 70 -30 2 0 {name=p12 sig_type=std_logic lab=sub_sample}
C {lab_pin.sym} 70 -50 2 0 {name=p13 sig_type=std_logic lab=smpl_out_n}
C {lab_pin.sym} 350 -120 1 0 {name=p14 sig_type=std_logic lab=vref}
C {lab_pin.sym} 240 -90 0 0 {name=p15 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} 240 -70 0 0 {name=p16 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 380 -50 2 0 {name=p17 sig_type=std_logic lab=smpl_n_d12_out_n}
C {lab_pin.sym} 380 -30 2 0 {name=p18 sig_type=std_logic lab=sub_sample}
C {opin.sym} -200 -260 2 0 {name=p1 lab=Vin}
C {lab_pin.sym} 280 0 3 0 {name=p19 sig_type=std_logic lab=Vin}
