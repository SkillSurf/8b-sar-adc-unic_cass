** sch_path: test/testbench/sar_tb1 _capdac.sch
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice

**.subckt sar_tb1 _capdac vdd vss
*.iopin vdd
*.iopin vss
Vdd8 rst_n GND pulse(1.8 0 1n 1n 1n 50n 100u 1)
Vdd4 clk GND pulse(0 1.8 0.1n 0.1n 1n 500n 1u)
Vdd1 vref GND 1.8
x3 net1 vss vss vcc vcc comp_out sky130_fd_sc_hd__inv_8
Vdd5 supply GND 1.8
V_VCM_2 vcm GND 0.9
V_VCM_1 vinp vcm 0.1
V_VCM_3 vcm vinm 0.1
I0 vdd ibn_1u 1u
x68 clk vss vss vdd vdd net2 sky130_fd_sc_hd__buf_1
x70 net2 vss vss vdd vdd net3 sky130_fd_sc_hd__buf_1
x72 net4 vss vss vcc vcc latch sky130_fd_sc_hd__inv_2
XM27 GND net2 GND GND sky130_fd_pr__nfet_01v8 L=5 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM1 GND net3 GND GND sky130_fd_pr__nfet_01v8 L=5 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
x69 net3 vss vss vdd vdd net4 sky130_fd_sc_hd__buf_1
x1 vdd net1 ibn_1u comp_p comp_m vss latch adc_comp
x2 clk data_rdy smpl rst_n smpl_n comp_out GND supply data7 data6 data5 data4 data3 data2 data1
+ data0 data_n7 data_n6 data_n5 data_n4 data_n3 data_n2 data_n1 data_n0 sar_controller
x3[7] data7 vss vss vcc vcc net5[7] sky130_fd_sc_hd__inv_2
x3[6] data6 vss vss vcc vcc net5[6] sky130_fd_sc_hd__inv_2
x3[5] data5 vss vss vcc vcc net5[5] sky130_fd_sc_hd__inv_2
x3[4] data4 vss vss vcc vcc net5[4] sky130_fd_sc_hd__inv_2
x3[3] data3 vss vss vcc vcc net5[3] sky130_fd_sc_hd__inv_2
x3[2] data2 vss vss vcc vcc net5[2] sky130_fd_sc_hd__inv_2
x3[1] data1 vss vss vcc vcc net5[1] sky130_fd_sc_hd__inv_2
x3[0] data0 vss vss vcc vcc net5[0] sky130_fd_sc_hd__inv_2
x4[7] data7 d7 vss vss vdd vdd net6[7] sky130_fd_sc_hd__nor2_1
x4[6] data6 d6 vss vss vdd vdd net6[6] sky130_fd_sc_hd__nor2_1
x4[5] data5 d5 vss vss vdd vdd net6[5] sky130_fd_sc_hd__nor2_1
x4[4] data4 d4 vss vss vdd vdd net6[4] sky130_fd_sc_hd__nor2_1
x4[3] data3 d3 vss vss vdd vdd net6[3] sky130_fd_sc_hd__nor2_1
x4[2] data2 d2 vss vss vdd vdd net6[2] sky130_fd_sc_hd__nor2_1
x4[1] data1 d1 vss vss vdd vdd net6[1] sky130_fd_sc_hd__nor2_1
x4[0] data0 d0 vss vss vdd vdd net6[0] sky130_fd_sc_hd__nor2_1
x5[7] dn7 net5[7] vss vss vdd vdd net9[7] sky130_fd_sc_hd__nor2_1
x5[6] dn6 net5[6] vss vss vdd vdd net9[6] sky130_fd_sc_hd__nor2_1
x5[5] dn5 net5[5] vss vss vdd vdd net9[5] sky130_fd_sc_hd__nor2_1
x5[4] dn4 net5[4] vss vss vdd vdd net9[4] sky130_fd_sc_hd__nor2_1
x5[3] dn3 net5[3] vss vss vdd vdd net9[3] sky130_fd_sc_hd__nor2_1
x5[2] dn2 net5[2] vss vss vdd vdd net9[2] sky130_fd_sc_hd__nor2_1
x5[1] dn1 net5[1] vss vss vdd vdd net9[1] sky130_fd_sc_hd__nor2_1
x5[0] dn0 net5[0] vss vss vdd vdd net9[0] sky130_fd_sc_hd__nor2_1
x6[7] net6[7] vss vss vdd vdd net7[7] sky130_fd_sc_hd__buf_1
x6[6] net6[6] vss vss vdd vdd net7[6] sky130_fd_sc_hd__buf_1
x6[5] net6[5] vss vss vdd vdd net7[5] sky130_fd_sc_hd__buf_1
x6[4] net6[4] vss vss vdd vdd net7[4] sky130_fd_sc_hd__buf_1
x6[3] net6[3] vss vss vdd vdd net7[3] sky130_fd_sc_hd__buf_1
x6[2] net6[2] vss vss vdd vdd net7[2] sky130_fd_sc_hd__buf_1
x6[1] net6[1] vss vss vdd vdd net7[1] sky130_fd_sc_hd__buf_1
x6[0] net6[0] vss vss vdd vdd net7[0] sky130_fd_sc_hd__buf_1
x7[7] net7[7] vss vss vdd vdd net8[7] sky130_fd_sc_hd__buf_1
x7[6] net7[6] vss vss vdd vdd net8[6] sky130_fd_sc_hd__buf_1
x7[5] net7[5] vss vss vdd vdd net8[5] sky130_fd_sc_hd__buf_1
x7[4] net7[4] vss vss vdd vdd net8[4] sky130_fd_sc_hd__buf_1
x7[3] net7[3] vss vss vdd vdd net8[3] sky130_fd_sc_hd__buf_1
x7[2] net7[2] vss vss vdd vdd net8[2] sky130_fd_sc_hd__buf_1
x7[1] net7[1] vss vss vdd vdd net8[1] sky130_fd_sc_hd__buf_1
x7[0] net7[0] vss vss vdd vdd net8[0] sky130_fd_sc_hd__buf_1
x8[7] net8[7] vss vss vdd vdd dn7 sky130_fd_sc_hd__buf_1
x8[6] net8[6] vss vss vdd vdd dn6 sky130_fd_sc_hd__buf_1
x8[5] net8[5] vss vss vdd vdd dn5 sky130_fd_sc_hd__buf_1
x8[4] net8[4] vss vss vdd vdd dn4 sky130_fd_sc_hd__buf_1
x8[3] net8[3] vss vss vdd vdd dn3 sky130_fd_sc_hd__buf_1
x8[2] net8[2] vss vss vdd vdd dn2 sky130_fd_sc_hd__buf_1
x8[1] net8[1] vss vss vdd vdd dn1 sky130_fd_sc_hd__buf_1
x8[0] net8[0] vss vss vdd vdd dn0 sky130_fd_sc_hd__buf_1
x9[7] net9[7] vss vss vdd vdd net10[7] sky130_fd_sc_hd__buf_1
x9[6] net9[6] vss vss vdd vdd net10[6] sky130_fd_sc_hd__buf_1
x9[5] net9[5] vss vss vdd vdd net10[5] sky130_fd_sc_hd__buf_1
x9[4] net9[4] vss vss vdd vdd net10[4] sky130_fd_sc_hd__buf_1
x9[3] net9[3] vss vss vdd vdd net10[3] sky130_fd_sc_hd__buf_1
x9[2] net9[2] vss vss vdd vdd net10[2] sky130_fd_sc_hd__buf_1
x9[1] net9[1] vss vss vdd vdd net10[1] sky130_fd_sc_hd__buf_1
x9[0] net9[0] vss vss vdd vdd net10[0] sky130_fd_sc_hd__buf_1
x10[7] net10[7] vss vss vdd vdd net11[7] sky130_fd_sc_hd__buf_1
x10[6] net10[6] vss vss vdd vdd net11[6] sky130_fd_sc_hd__buf_1
x10[5] net10[5] vss vss vdd vdd net11[5] sky130_fd_sc_hd__buf_1
x10[4] net10[4] vss vss vdd vdd net11[4] sky130_fd_sc_hd__buf_1
x10[3] net10[3] vss vss vdd vdd net11[3] sky130_fd_sc_hd__buf_1
x10[2] net10[2] vss vss vdd vdd net11[2] sky130_fd_sc_hd__buf_1
x10[1] net10[1] vss vss vdd vdd net11[1] sky130_fd_sc_hd__buf_1
x10[0] net10[0] vss vss vdd vdd net11[0] sky130_fd_sc_hd__buf_1
x11[7] net11[7] vss vss vdd vdd d7 sky130_fd_sc_hd__buf_1
x11[6] net11[6] vss vss vdd vdd d6 sky130_fd_sc_hd__buf_1
x11[5] net11[5] vss vss vdd vdd d5 sky130_fd_sc_hd__buf_1
x11[4] net11[4] vss vss vdd vdd d4 sky130_fd_sc_hd__buf_1
x11[3] net11[3] vss vss vdd vdd d3 sky130_fd_sc_hd__buf_1
x11[2] net11[2] vss vss vdd vdd d2 sky130_fd_sc_hd__buf_1
x11[1] net11[1] vss vss vdd vdd d1 sky130_fd_sc_hd__buf_1
x11[0] net11[0] vss vss vdd vdd d0 sky130_fd_sc_hd__buf_1
x13[7] dn7 vss vss vcc vcc dn_n7 sky130_fd_sc_hd__inv_2
x13[6] dn6 vss vss vcc vcc dn_n6 sky130_fd_sc_hd__inv_2
x13[5] dn5 vss vss vcc vcc dn_n5 sky130_fd_sc_hd__inv_2
x13[4] dn4 vss vss vcc vcc dn_n4 sky130_fd_sc_hd__inv_2
x13[3] dn3 vss vss vcc vcc dn_n3 sky130_fd_sc_hd__inv_2
x13[2] dn2 vss vss vcc vcc dn_n2 sky130_fd_sc_hd__inv_2
x13[1] dn1 vss vss vcc vcc dn_n1 sky130_fd_sc_hd__inv_2
x13[0] dn0 vss vss vcc vcc dn_n0 sky130_fd_sc_hd__inv_2
x14[7] d7 vss vss vcc vcc d_n7 sky130_fd_sc_hd__inv_2
x14[6] d6 vss vss vcc vcc d_n6 sky130_fd_sc_hd__inv_2
x14[5] d5 vss vss vcc vcc d_n5 sky130_fd_sc_hd__inv_2
x14[4] d4 vss vss vcc vcc d_n4 sky130_fd_sc_hd__inv_2
x14[3] d3 vss vss vcc vcc d_n3 sky130_fd_sc_hd__inv_2
x14[2] d2 vss vss vcc vcc d_n2 sky130_fd_sc_hd__inv_2
x14[1] d1 vss vss vcc vcc d_n1 sky130_fd_sc_hd__inv_2
x14[0] d0 vss vss vcc vcc d_n0 sky130_fd_sc_hd__inv_2
x15[7] d7 net24 vss vss vcc vcc phi17 sky130_fd_sc_hd__or2_1
x15[6] d6 net24 vss vss vcc vcc phi16 sky130_fd_sc_hd__or2_1
x15[5] d5 net24 vss vss vcc vcc phi15 sky130_fd_sc_hd__or2_1
x15[4] d4 net24 vss vss vcc vcc phi14 sky130_fd_sc_hd__or2_1
x15[3] d3 net24 vss vss vcc vcc phi13 sky130_fd_sc_hd__or2_1
x15[2] d2 net24 vss vss vcc vcc phi12 sky130_fd_sc_hd__or2_1
x15[1] d1 net24 vss vss vcc vcc phi11 sky130_fd_sc_hd__or2_1
x15[0] d0 net24 vss vss vcc vcc phi10 sky130_fd_sc_hd__or2_1
x7 smpl vss vss vdd vdd net12 sky130_fd_sc_hd__buf_1
x8 net12 vss vss vdd vdd net13 sky130_fd_sc_hd__buf_1
x9 net13 vss vss vdd vdd net14 sky130_fd_sc_hd__buf_1
x10 net14 vss vss vdd vdd net15 sky130_fd_sc_hd__buf_1
x11 net15 vss vss vdd vdd net17 sky130_fd_sc_hd__buf_1
x12 net17 vss vss vdd vdd net16 sky130_fd_sc_hd__buf_1
x16[7] phi17 vss vss vcc vcc phi1_n7 sky130_fd_sc_hd__inv_2
x16[6] phi16 vss vss vcc vcc phi1_n6 sky130_fd_sc_hd__inv_2
x16[5] phi15 vss vss vcc vcc phi1_n5 sky130_fd_sc_hd__inv_2
x16[4] phi14 vss vss vcc vcc phi1_n4 sky130_fd_sc_hd__inv_2
x16[3] phi13 vss vss vcc vcc phi1_n3 sky130_fd_sc_hd__inv_2
x16[2] phi12 vss vss vcc vcc phi1_n2 sky130_fd_sc_hd__inv_2
x16[1] phi11 vss vss vcc vcc phi1_n1 sky130_fd_sc_hd__inv_2
x16[0] phi10 vss vss vcc vcc phi1_n0 sky130_fd_sc_hd__inv_2
x17[7] smpl_n_d12 dn7 vss vss vcc vcc phi27 sky130_fd_sc_hd__and2_2
x17[6] smpl_n_d12 dn6 vss vss vcc vcc phi26 sky130_fd_sc_hd__and2_2
x17[5] smpl_n_d12 dn5 vss vss vcc vcc phi25 sky130_fd_sc_hd__and2_2
x17[4] smpl_n_d12 dn4 vss vss vcc vcc phi24 sky130_fd_sc_hd__and2_2
x17[3] smpl_n_d12 dn3 vss vss vcc vcc phi23 sky130_fd_sc_hd__and2_2
x17[2] smpl_n_d12 dn2 vss vss vcc vcc phi22 sky130_fd_sc_hd__and2_2
x17[1] smpl_n_d12 dn1 vss vss vcc vcc phi21 sky130_fd_sc_hd__and2_2
x17[0] smpl_n_d12 dn0 vss vss vcc vcc phi20 sky130_fd_sc_hd__and2_2
x13 net16 vss vss vdd vdd net18 sky130_fd_sc_hd__buf_1
x14 net18 vss vss vdd vdd net19 sky130_fd_sc_hd__buf_1
x15 net19 vss vss vdd vdd net20 sky130_fd_sc_hd__buf_1
x16 net20 vss vss vdd vdd net22 sky130_fd_sc_hd__buf_1
x17 net22 vss vss vdd vdd net21 sky130_fd_sc_hd__buf_2
x35 net21 vss vss vdd vdd net23 sky130_fd_sc_hd__buf_4
x36 net23 vss vss vdd vdd net24 sky130_fd_sc_hd__buf_6
x37 net30 vss vss vcc vcc smpl_n_d12 sky130_fd_sc_hd__inv_8
x38 net24 vss vss vdd vdd net25 sky130_fd_sc_hd__buf_1
x39 net25 vss vss vdd vdd net26 sky130_fd_sc_hd__buf_1
x40 net26 vss vss vdd vdd net28 sky130_fd_sc_hd__buf_1
x41 net28 vss vss vdd vdd net27 sky130_fd_sc_hd__buf_2
x42 net27 vss vss vdd vdd net29 sky130_fd_sc_hd__buf_4
x43 net29 vss vss vdd vdd net30 sky130_fd_sc_hd__buf_6
x18[7] phi27 vss vss vcc vcc phi2_n7 sky130_fd_sc_hd__inv_2
x18[6] phi26 vss vss vcc vcc phi2_n6 sky130_fd_sc_hd__inv_2
x18[5] phi25 vss vss vcc vcc phi2_n5 sky130_fd_sc_hd__inv_2
x18[4] phi24 vss vss vcc vcc phi2_n4 sky130_fd_sc_hd__inv_2
x18[3] phi23 vss vss vcc vcc phi2_n3 sky130_fd_sc_hd__inv_2
x18[2] phi22 vss vss vcc vcc phi2_n2 sky130_fd_sc_hd__inv_2
x18[1] phi21 vss vss vcc vcc phi2_n1 sky130_fd_sc_hd__inv_2
x18[0] phi20 vss vss vcc vcc phi2_n0 sky130_fd_sc_hd__inv_2
x44 smpl vss vss vcc vcc smpl_out_n sky130_fd_sc_hd__inv_8
x45 smpl_n_d12 vss vss vcc vcc smpl_n_d12_out_n sky130_fd_sc_hd__inv_8
x4 GND GND GND GND GND GND GND GND GND vdd GND smpl phi17 phi16 phi15 phi14 phi13 phi12 phi11 phi10
+ phi1_n7 phi1_n6 phi1_n5 phi1_n4 phi1_n3 phi1_n2 phi1_n1 phi1_n0 smpl_out_n phi27 phi26 phi25 phi24 phi23
+ phi22 phi21 phi20 smpl_n_d12 smpl_n_d12_out_n phi2_n7 phi2_n6 phi2_n5 phi2_n4 phi2_n3 phi2_n2 phi2_n1
+ phi2_n0 comp_p net31 capblock_256
x5 GND GND GND GND GND GND GND GND GND vdd GND vdd dn7 dn6 dn5 dn4 dn3 dn2 dn1 dn0 dn_n7 dn_n6 dn_n5
+ dn_n4 dn_n3 dn_n2 dn_n1 dn_n0 GND d7 d6 d5 d4 d3 d2 d1 d0 GND vdd d_n7 d_n6 d_n5 d_n4 d_n3 d_n2 d_n1 d_n0
+ comp_m net32 capblock_256
x210 smpl GND comp_p vcm vdd smpl_out_n tg_final
x29 smpl GND comp_p vcm vdd smpl_out_n tg_final
x28 smpl GND comp_p vcm vdd smpl_out_n tg_final
x27 smpl GND comp_p vcm vdd smpl_out_n tg_final
x26 smpl GND comp_p vcm vdd smpl_out_n tg_final
x25 smpl GND comp_p vcm vdd smpl_out_n tg_final
x24 smpl GND comp_p vcm vdd smpl_out_n tg_final
x23 smpl GND comp_p vcm vdd smpl_out_n tg_final
x22 smpl GND comp_p vcm vdd smpl_out_n tg_final
x21 smpl GND comp_p vcm vdd smpl_out_n tg_final
x20 smpl GND comp_p vcm vdd smpl_out_n tg_final
x1810 smpl GND comp_m vcm vdd smpl_out_n tg_final
x189 smpl GND comp_m vcm vdd smpl_out_n tg_final
x188 smpl GND comp_m vcm vdd smpl_out_n tg_final
x187 smpl GND comp_m vcm vdd smpl_out_n tg_final
x186 smpl GND comp_m vcm vdd smpl_out_n tg_final
x185 smpl GND comp_m vcm vdd smpl_out_n tg_final
x184 smpl GND comp_m vcm vdd smpl_out_n tg_final
x183 smpl GND comp_m vcm vdd smpl_out_n tg_final
x182 smpl GND comp_m vcm vdd smpl_out_n tg_final
x181 smpl GND comp_m vcm vdd smpl_out_n tg_final
x180 smpl GND comp_m vcm vdd smpl_out_n tg_final
x510 smpl GND net31 vinp vdd smpl_out_n tg_final
x59 smpl GND net31 vinp vdd smpl_out_n tg_final
x58 smpl GND net31 vinp vdd smpl_out_n tg_final
x57 smpl GND net31 vinp vdd smpl_out_n tg_final
x56 smpl GND net31 vinp vdd smpl_out_n tg_final
x55 smpl GND net31 vinp vdd smpl_out_n tg_final
x54 smpl GND net31 vinp vdd smpl_out_n tg_final
x53 smpl GND net31 vinp vdd smpl_out_n tg_final
x52 smpl GND net31 vinp vdd smpl_out_n tg_final
x51 smpl GND net31 vinp vdd smpl_out_n tg_final
x50 smpl GND net31 vinp vdd smpl_out_n tg_final
x810 smpl GND net32 vinm vdd smpl_out_n tg_final
x89 smpl GND net32 vinm vdd smpl_out_n tg_final
x88 smpl GND net32 vinm vdd smpl_out_n tg_final
x87 smpl GND net32 vinm vdd smpl_out_n tg_final
x86 smpl GND net32 vinm vdd smpl_out_n tg_final
x85 smpl GND net32 vinm vdd smpl_out_n tg_final
x84 smpl GND net32 vinm vdd smpl_out_n tg_final
x83 smpl GND net32 vinm vdd smpl_out_n tg_final
x82 smpl GND net32 vinm vdd smpl_out_n tg_final
x81 smpl GND net32 vinm vdd smpl_out_n tg_final
x80 smpl GND net32 vinm vdd smpl_out_n tg_final
x910 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x99 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x98 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x97 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x96 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x95 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x94 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x93 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x92 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x91 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x90 smpl_n_d12 GND net31 vref vdd smpl_n_d12_out_n tg_final
x1010 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
x109 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
x108 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
x107 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
x106 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
x105 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
x104 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
x103 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
x102 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
x101 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
x100 smpl_n_d12 GND net32 vref vdd smpl_n_d12_out_n tg_final
**** begin user architecture code


.tran 10n 30u
.save all
.param vcc = 1.8
.param vdd = 1.8
.param vdiff = 200m
vvcc vcc 0 dc vcc
vvdd vdd 0 dc vdd
vvss vss 0 0
.control

run
plot comp_p comp_m
plot d0+2 d1+4 d2+6 d3+8 d4+10 d5+12 d6+14 d7+16 data_rdy+18
plot x2.net21 x2.net2+2 x2.net10+4 x2.net19+6
write sar_tb1.raw comp_p comp_m
set wr_singlescale
set wr_vecnames
wrdata sar1.txt comp_p comp_m d0 d1 d2 d3 d4 d5 d6 d7 data_rdy vinp vinm
.endc



.model SWITCH1 sw vt=0.9 vh=0 ron=1 roff =100G

**** end user architecture code
**.ends

* expanding   symbol:
*+  /home/shevi/whyRD_eda_bundle/sar_adc/8b-sar-adc-unic_cass-main/test/design/adc_comp.sym # of pins=7
** sym_path: test/design/adc_comp.sym
** sch_path: test/design/adc_comp.sch
.subckt adc_comp vdd vo ibn_1u vp vm vss latch
*.iopin vss
*.iopin vdd
*.ipin vp
*.ipin vm
*.ipin latch
*.ipin ibn_1u
*.opin vo
XM3 vom1 vp vx vss sky130_fd_pr__nfet_01v8_lvt L=1 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM4 vop1 vm vx vss sky130_fd_pr__nfet_01v8_lvt L=1 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM2 vop1 vbp vdd vdd sky130_fd_pr__pfet_01v8_lvt L=5 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=5 m=5
XM1 vom1 vbp vdd vdd sky130_fd_pr__pfet_01v8_lvt L=5 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=5 m=5
XM6 ibn_1u ibn_1u vss vss sky130_fd_pr__nfet_01v8 L=20 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM5 vx ibn_1u vss vss sky130_fd_pr__nfet_01v8 L=20 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=12 m=12
XM7 vbp ibn_1u vss vss sky130_fd_pr__nfet_01v8 L=20 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 vbp vbp vdd vdd sky130_fd_pr__pfet_01v8_lvt L=5 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM9 vx vop1 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=1 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM10 vx vom1 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=1 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM11 vop2 vom2 vss vss sky130_fd_pr__nfet_01v8 L=2 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM12 vom2 vop2 vss vss sky130_fd_pr__nfet_01v8 L=2 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM13 net4 vom1 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=0.4 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM14 net3 vop1 vdd vdd sky130_fd_pr__pfet_01v8_lvt L=0.4 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM17 vom2 latch_n vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM18 vop2 latch_n vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM19 net1 vop2 vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM20 net1 vop2 vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM21 vo net1 vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM22 vo net1 vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM23 net2 vom2 vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM24 net2 vom2 vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM15 net5 vop2 net3 vdd sky130_fd_pr__pfet_01v8_lvt L=0.4 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM16 net6 vom2 net4 vdd sky130_fd_pr__pfet_01v8_lvt L=0.4 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM25 net5 latch vom2 vss sky130_fd_pr__nfet_01v8_lvt L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM26 net6 latch vop2 vss sky130_fd_pr__nfet_01v8_lvt L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
x30 latch vss vss vdd vdd latch_n sky130_fd_sc_hd__inv_1
XM27 vss ibn_1u vss vss sky130_fd_pr__nfet_01v8 L=20 W=3 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM28 vss vss vss vss sky130_fd_pr__nfet_01v8_lvt L=1 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM29 vss vss vss vss sky130_fd_pr__nfet_01v8_lvt L=1 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=20 m=20
XM30 vdd vbp vdd vdd sky130_fd_pr__pfet_01v8_lvt L=5 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM31 vdd vdd vdd vdd sky130_fd_pr__pfet_01v8_lvt L=1 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
.ends


* expanding   symbol:
*+  /home/shevi/whyRD_eda_bundle/sar_adc/8b-sar-adc-unic_cass-main/test/design/sar_controller.sym # of pins=10
** sym_path: test/design/sar_controller.sym
** sch_path: test/design/sar_controller.sch
.subckt sar_controller clk data_rdy smpl rst_n smpl_n comp_out vss vdd d7 d6 d5 d4 d3 d2 d1 d0 d_n7
+ d_n6 d_n5 d_n4 d_n3 d_n2 d_n1 d_n0
*.ipin rst_n
*.opin data_rdy
*.ipin clk
*.opin smpl
*.ipin comp_out
*.iopin vss
*.iopin vdd
*.opin d7,d6,d5,d4,d3,d2,d1,d0
*.opin d_n7,d_n6,d_n5,d_n4,d_n3,d_n2,d_n1,d_n0
*.opin smpl_n
x26 net2 net21 net22 net9 vss vss vdd vdd net1 net25 sky130_fd_sc_hd__dfbbp_1
x5 net19 net23 net20 vss vss vdd vdd cnv_7 net9 sky130_fd_sc_hd__dfrbp_1
* noconn #net33
x24 net19 net8 net20 vss vss vdd vdd net23 net24 sky130_fd_sc_hd__dfsbp_1
x6 net24 net20 vss vss vdd vdd net22 sky130_fd_sc_hd__and2_4
x1 net19 cnv_7 net20 vss vss vdd vdd cnv_6 net12 sky130_fd_sc_hd__dfrbp_1
x2 net19 cnv_6 net20 vss vss vdd vdd cnv_5 net13 sky130_fd_sc_hd__dfrbp_1
x3 net19 cnv_5 net20 vss vss vdd vdd cnv_4 net14 sky130_fd_sc_hd__dfrbp_1
x4 net19 cnv_4 net20 vss vss vdd vdd cnv_3 net15 sky130_fd_sc_hd__dfrbp_1
x7 net19 cnv_3 net20 vss vss vdd vdd cnv_2 net16 sky130_fd_sc_hd__dfrbp_1
x8 net19 cnv_2 net20 vss vss vdd vdd cnv_1 net17 sky130_fd_sc_hd__dfrbp_1
x9 net19 cnv_1 net20 vss vss vdd vdd cnv_0 net18 sky130_fd_sc_hd__dfrbp_1
x10 net19 cnv_0 net20 vss vss vdd vdd net8 net33 sky130_fd_sc_hd__dfrbp_1
x11 vss vss net22 vss vss vdd vdd net11 net34 sky130_fd_sc_hd__dfrbp_1
x12 net10 net21 net22 net12 vss vss vdd vdd net2 net26 sky130_fd_sc_hd__dfbbp_1
x13 net3 net21 net22 net13 vss vss vdd vdd net10 net27 sky130_fd_sc_hd__dfbbp_1
x14 net4 net21 net22 net14 vss vss vdd vdd net3 net28 sky130_fd_sc_hd__dfbbp_1
x15 net5 net21 net22 net15 vss vss vdd vdd net4 net29 sky130_fd_sc_hd__dfbbp_1
x16 net6 net21 net22 net16 vss vss vdd vdd net5 net30 sky130_fd_sc_hd__dfbbp_1
x17 net7 net21 net22 net17 vss vss vdd vdd net6 net31 sky130_fd_sc_hd__dfbbp_1
x18 net11 net21 net22 net18 vss vss vdd vdd net7 net32 sky130_fd_sc_hd__dfbbp_1
* noconn #net34
x19 net1 vss vss vdd vdd d7 sky130_fd_sc_hd__buf_2
x20 net25 vss vss vdd vdd d_n7 sky130_fd_sc_hd__buf_2
x21 net2 vss vss vdd vdd d6 sky130_fd_sc_hd__buf_2
x22 net26 vss vss vdd vdd d_n6 sky130_fd_sc_hd__buf_2
x23 net10 vss vss vdd vdd d5 sky130_fd_sc_hd__buf_2
x25 net27 vss vss vdd vdd d_n5 sky130_fd_sc_hd__buf_2
x27 net3 vss vss vdd vdd d4 sky130_fd_sc_hd__buf_2
x28 net28 vss vss vdd vdd d_n4 sky130_fd_sc_hd__buf_2
x29 net4 vss vss vdd vdd d3 sky130_fd_sc_hd__buf_2
x30 net29 vss vss vdd vdd d_n3 sky130_fd_sc_hd__buf_2
x31 net5 vss vss vdd vdd d2 sky130_fd_sc_hd__buf_2
x32 net30 vss vss vdd vdd d_n2 sky130_fd_sc_hd__buf_2
x33 net6 vss vss vdd vdd d1 sky130_fd_sc_hd__buf_2
x34 net31 vss vss vdd vdd d_n1 sky130_fd_sc_hd__buf_2
x35 net7 vss vss vdd vdd d0 sky130_fd_sc_hd__buf_2
x36 net32 vss vss vdd vdd d_n0 sky130_fd_sc_hd__buf_2
x37 net23 vss vss vdd vdd smpl sky130_fd_sc_hd__buf_2
x38 net24 vss vss vdd vdd smpl_n sky130_fd_sc_hd__buf_2
x39 net8 vss vss vdd vdd data_rdy sky130_fd_sc_hd__buf_2
x40 comp_out vss vss vdd vdd net21 sky130_fd_sc_hd__buf_4
x41 rst_n vss vss vdd vdd net20 sky130_fd_sc_hd__buf_4
x42 clk vss vss vdd vdd net19 sky130_fd_sc_hd__buf_4
.ends


* expanding   symbol:  capblock_256.sym # of pins=14
** sym_path: test/design/capblock_256.sym
** sch_path: test/design/capblock_256.sch
.subckt capblock_256 sub7 sub6 sub5 sub4 sub3 sub2 sub1 sub0 GND vdd sub_sample smpl phi17 phi16
+ phi15 phi14 phi13 phi12 phi11 phi10 phi1_n7 phi1_n6 phi1_n5 phi1_n4 phi1_n3 phi1_n2 phi1_n1 phi1_n0
+ smpl_out_n phi27 phi26 phi25 phi24 phi23 phi22 phi21 phi20 smpl_n_d12 smpl_n_d12_out_n phi2_n7 phi2_n6 phi2_n5
+ phi2_n4 phi2_n3 phi2_n2 phi2_n1 phi2_n0 com_x Vin
*.ipin phi17,phi16,phi15,phi14,phi13,phi12,phi11,phi10
*.ipin phi1_n7,phi1_n6,phi1_n5,phi1_n4,phi1_n3,phi1_n2,phi1_n1,phi1_n0
*.iopin vdd
*.iopin GND
*.iopin sub7,sub6,sub5,sub4,sub3,sub2,sub1,sub0
*.ipin phi27,phi26,phi25,phi24,phi23,phi22,phi21,phi20
*.ipin phi2_n7,phi2_n6,phi2_n5,phi2_n4,phi2_n3,phi2_n2,phi2_n1,phi2_n0
*.ipin Vin
*.opin com_x
*.ipin smpl
*.ipin smpl_out_n
*.ipin smpl_n_d12
*.ipin smpl_n_d12_out_n
*.iopin sub_sample
x8 Vin sub0 GND vdd phi10 phi20 phi2_n0 phi1_n0 com_x cap_switch_block
x9[1] Vin sub1 GND vdd phi11 phi21 phi2_n1 phi1_n1 com_x cap_switch_block
x9[0] Vin sub1 GND vdd phi11 phi21 phi2_n1 phi1_n1 com_x cap_switch_block
x4[3] Vin sub2 GND vdd phi12 phi22 phi2_n2 phi1_n2 com_x cap_switch_block
x4[2] Vin sub2 GND vdd phi12 phi22 phi2_n2 phi1_n2 com_x cap_switch_block
x4[1] Vin sub2 GND vdd phi12 phi22 phi2_n2 phi1_n2 com_x cap_switch_block
x4[0] Vin sub2 GND vdd phi12 phi22 phi2_n2 phi1_n2 com_x cap_switch_block
x5[7] Vin sub3 GND vdd phi13 phi23 phi2_n3 phi1_n3 com_x cap_switch_block
x5[6] Vin sub3 GND vdd phi13 phi23 phi2_n3 phi1_n3 com_x cap_switch_block
x5[5] Vin sub3 GND vdd phi13 phi23 phi2_n3 phi1_n3 com_x cap_switch_block
x5[4] Vin sub3 GND vdd phi13 phi23 phi2_n3 phi1_n3 com_x cap_switch_block
x5[3] Vin sub3 GND vdd phi13 phi23 phi2_n3 phi1_n3 com_x cap_switch_block
x5[2] Vin sub3 GND vdd phi13 phi23 phi2_n3 phi1_n3 com_x cap_switch_block
x5[1] Vin sub3 GND vdd phi13 phi23 phi2_n3 phi1_n3 com_x cap_switch_block
x5[0] Vin sub3 GND vdd phi13 phi23 phi2_n3 phi1_n3 com_x cap_switch_block
x6[15] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[14] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[13] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[12] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[11] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[10] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[9] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[8] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[7] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[6] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[5] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[4] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[3] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[2] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[1] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x6[0] Vin sub4 GND vdd phi14 phi24 phi2_n4 phi1_n4 com_x cap_switch_block
x7[31] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[30] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[29] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[28] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[27] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[26] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[25] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[24] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[23] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[22] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[21] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[20] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[19] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[18] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[17] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[16] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[15] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[14] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[13] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[12] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[11] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[10] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[9] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[8] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[7] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[6] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[5] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[4] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[3] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[2] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[1] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x7[0] Vin sub5 GND vdd phi15 phi25 phi2_n5 phi1_n5 com_x cap_switch_block
x8[63] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[62] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[61] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[60] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[59] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[58] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[57] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[56] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[55] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[54] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[53] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[52] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[51] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[50] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[49] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[48] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[47] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[46] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[45] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[44] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[43] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[42] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[41] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[40] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[39] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[38] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[37] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[36] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[35] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[34] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[33] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[32] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[31] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[30] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[29] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[28] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[27] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[26] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[25] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[24] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[23] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[22] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[21] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[20] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[19] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[18] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[17] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[16] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[15] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[14] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[13] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[12] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[11] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[10] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[9] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[8] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[7] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[6] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[5] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[4] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[3] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[2] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[1] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x8[0] Vin sub6 GND vdd phi16 phi26 phi2_n6 phi1_n6 com_x cap_switch_block
x10[128] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[127] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[126] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[125] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[124] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[123] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[122] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[121] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[120] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[119] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[118] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[117] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[116] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[115] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[114] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[113] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[112] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[111] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[110] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[109] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[108] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[107] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[106] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[105] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[104] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[103] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[102] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[101] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[100] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[99] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[98] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[97] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[96] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[95] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[94] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[93] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[92] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[91] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[90] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[89] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[88] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[87] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[86] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[85] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[84] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[83] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[82] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[81] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[80] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[79] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[78] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[77] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[76] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[75] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[74] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[73] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[72] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[71] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[70] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[69] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[68] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[67] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[66] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[65] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[64] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[63] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[62] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[61] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[60] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[59] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[58] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[57] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[56] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[55] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[54] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[53] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[52] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[51] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[50] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[49] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[48] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[47] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[46] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[45] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[44] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[43] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[42] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[41] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[40] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[39] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[38] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[37] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[36] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[35] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[34] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[33] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[32] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[31] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[30] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[29] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[28] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[27] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[26] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[25] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[24] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[23] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[22] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[21] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[20] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[19] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[18] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[17] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[16] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[15] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[14] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[13] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[12] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[11] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[10] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[9] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[8] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[7] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[6] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[5] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[4] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[3] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[2] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[1] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x10[0] Vin sub7 GND vdd phi17 phi27 phi2_n7 phi1_n7 com_x cap_switch_block
x1 Vin sub_sample GND vdd smpl smpl_n_d12 smpl_n_d12_out_n smpl_out_n com_x cap_switch_block
.ends


* expanding   symbol:  final/tg_final.sym # of pins=6
** sym_path: top/test/design/tg_final.sym
** sch_path: top/test/design/tg_final.sch
.subckt tg_final clk sub vout vin vdd clk_b
*.ipin clk
*.ipin vin
*.opin vout
*.ipin vdd
*.ipin sub
*.ipin clk_b
XM2 vout clk vin sub sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 vout clk_b vin vdd sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  cap_switch_block.sym # of pins=9
** sym_path: test/design/cap_switch_block.sym
** sch_path: test/design/cap_switch_block.sch
.subckt cap_switch_block Vin sub GND Vdd phi1 phi2 phi2_n phi1_n com_x
*.ipin Vin
*.opin com_x
*.ipin phi1
*.ipin phi1_n
*.iopin Vdd
*.iopin GND
*.iopin sub
*.ipin phi2
*.ipin phi2_n
XC9 com_x net1 sky130_fd_pr__cap_mim_m3_1 W=7 L=7 MF=1 m=1
x4 phi1 sub net1 Vin Vdd phi1_n tg_final
x1 phi2 sub net1 GND Vdd phi2_n tg_final
.ends

.GLOBAL GND
.end
