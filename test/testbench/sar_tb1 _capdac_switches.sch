v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 660 0 660 70 {
lab=comp_p}
N 660 110 660 190 {
lab=comp_m}
N 660 70 770 70 {
lab=comp_p}
N 660 110 770 110 {
lab=comp_m}
N -1040 870 -1040 880 {
lab=GND}
N -1100 750 -1100 770 {
lab=vcm}
N -1040 770 -980 770 {
lab=vcm}
N -980 750 -980 770 {
lab=vcm}
N -1040 770 -1040 810 {
lab=vcm}
N -1100 770 -1040 770 {
lab=vcm}
N 1170 60 1180 60 {
lab=vdd}
N 1170 100 1180 100 {
lab=vss}
N 860 60 870 60 {
lab=ibn_1u}
N 860 80 870 80 {
lab=comp_p}
N 860 100 870 100 {
lab=comp_m}
N 860 120 870 120 {
lab=latch}
N 1170 80 1180 80 {
lab=#net1}
N 770 70 770 80 {
lab=comp_p}
N 770 80 860 80 {
lab=comp_p}
N 770 100 770 110 {
lab=comp_m}
N 770 100 860 100 {
lab=comp_m}
N -1270 680 -1270 690 {
lab=vdd}
N -1270 750 -1270 760 {
lab=ibn_1u}
N 1180 80 1300 80 {
lab=#net1}
N 340 710 360 710 {
lab=#net2}
N 440 710 460 710 {
lab=#net2}
N 540 710 560 710 {
lab=#net3}
N 640 710 650 710 {
lab=#net4}
N 730 710 740 710 {
lab=latch}
N 350 710 350 760 {
lab=#net2}
N 550 710 550 760 {
lab=#net3}
N 320 800 320 810 {
lab=GND}
N 320 810 380 810 {
lab=GND}
N 380 800 380 810 {
lab=GND}
N 350 800 350 810 {
lab=GND}
N 520 800 520 810 {
lab=GND}
N 520 810 580 810 {
lab=GND}
N 580 800 580 810 {
lab=GND}
N 550 800 550 810 {
lab=GND}
N 360 710 440 710 {
lab=#net2}
N -2890 -1080 -2890 -1060 {
lab=data[7..0]}
N -2890 -980 -2890 -940 {
lab=#net5}
N -2890 -880 -2730 -880 {
lab=#net5}
N -2890 -940 -2890 -880 {
lab=#net5}
N -2610 -1060 -2570 -1060 {
lab=#net6}
N -2490 -1060 -2450 -1060 {
lab=#net7}
N -2370 -1060 -2340 -1060 {
lab=#net8}
N -2610 -900 -2570 -900 {
lab=#net9}
N -2490 -900 -2450 -900 {
lab=#net10}
N -2370 -900 -2340 -900 {
lab=#net11}
N -2260 -900 -2220 -900 {
lab=d[7..0]}
N -2260 -1060 -2220 -1060 {
lab=dn[7..0]}
N -2250 -1060 -2250 -1030 {
lab=dn[7..0]}
N -2760 -940 -2250 -1030 {
lab=dn[7..0]}
N -2760 -940 -2760 -920 {
lab=dn[7..0]}
N -2760 -920 -2730 -920 {
lab=dn[7..0]}
N -2250 -930 -2250 -900 {
lab=d[7..0]}
N -2760 -1020 -2250 -930 {
lab=d[7..0]}
N -2760 -1040 -2760 -1020 {
lab=d[7..0]}
N -2760 -1040 -2730 -1040 {
lab=d[7..0]}
N -2220 -1060 -2190 -1060 {
lab=dn[7..0]}
N -2220 -900 -2190 -900 {
lab=d[7..0]}
N -2890 -1080 -2740 -1080 {
lab=data[7..0]}
N -2920 -1080 -2890 -1080 {
lab=data[7..0]}
N -2740 -1080 -2730 -1080 {
lab=data[7..0]}
N -3350 -680 -3340 -680 {
lab=#net12}
N -3260 -680 -3250 -680 {
lab=#net13}
N -3170 -680 -3160 -680 {
lab=#net14}
N -3080 -680 -3070 -680 {
lab=#net15}
N -2900 -680 -2880 -680 {
lab=#net16}
N -2990 -680 -2980 -680 {
lab=#net17}
N -2030 -700 -2020 -700 {
lab=phi1[7..0]}
N -2200 -900 -2200 -720 {
lab=d[7..0]}
N -2200 -720 -2150 -720 {
lab=d[7..0]}
N -2210 -1170 -2210 -1060 {
lab=dn[7..0]}
N -2210 -1170 -2150 -1170 {
lab=dn[7..0]}
N -2880 -680 -2870 -680 {
lab=#net16}
N -2790 -680 -2780 -680 {
lab=#net18}
N -2700 -680 -2690 -680 {
lab=#net19}
N -2610 -680 -2600 -680 {
lab=#net20}
N -2430 -680 -2410 -680 {
lab=#net21}
N -2520 -680 -2510 -680 {
lab=#net22}
N -2410 -680 -2400 -680 {
lab=#net21}
N -2320 -680 -2310 -680 {
lab=#net23}
N -2230 -680 -2150 -680 {
lab=#net24}
N -2100 -600 -2090 -600 {
lab=#net25}
N -2010 -600 -2000 -600 {
lab=#net26}
N -1830 -600 -1810 -600 {
lab=#net27}
N -1920 -600 -1910 -600 {
lab=#net28}
N -1810 -600 -1800 -600 {
lab=#net27}
N -1720 -600 -1710 -600 {
lab=#net29}
N -2200 -600 -2180 -600 {
lab=#net24}
N -2200 -680 -2200 -600 {
lab=#net24}
N -1630 -600 -1560 -600 {
lab=#net30}
N -2030 -1190 -1980 -1190 {
lab=phi2[7..0]}
N 360 -40 360 -0 {
lab=comp_p}
N 360 -0 660 -0 {
lab=comp_p}
N 370 190 660 190 {
lab=comp_m}
N 370 190 370 220 {
lab=comp_m}
C {vsource.sym} -110 780 0 0 {name=Vdd8 value="pulse(1.8 0 1n 1n 1n 50n 100u 1)" savecurrent=false}
C {gnd.sym} -110 810 0 0 {name=l6 lab=GND}
C {vsource.sym} -320 780 0 0 {name=Vdd4 value="pulse(0 1.8 0.1n 0.1n 1n 500n 1u)" savecurrent=false}
C {gnd.sym} -320 810 0 0 {name=l7 lab=GND}
C {lab_pin.sym} -320 750 1 0 {name=p98 sig_type=std_logic lab=clk}
C {lab_pin.sym} -110 750 1 0 {name=p99 sig_type=std_logic lab=rst_n}
C {devices/code.sym} -3210 -1500 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/code_shown.sym} -3050 -1660 0 0 {name=STIMULI
only_toplevel=true
value="
.tran 10n 20u
.save all
.param vcc = 1.8
.param vdd = 1.8
.param vdiff = 200m
vvcc vcc 0 dc vcc
vvdd vdd 0 dc vdd
vvss vss 0 0
.control

run
plot comp_p comp_m
plot d0+2 d1+4 d2+6 d3+8 d4+10 d5+12 d6+14 d7+16 data_rdy+18
plot x2.net21 x2.net2+2 x2.net10+4 x2.net19+6
write sar_tb1.raw comp_p comp_m
set wr_singlescale
set wr_vecnames
wrdata sar1.txt comp_p comp_m d0 d1 d2 d3 d4 d5 d6 d7 data_rdy vinp vinm
.endc
"}
C {code.sym} -3350 -1500 0 0 {name=SWITCH1 only_toplevel=false value=".model SWITCH1 sw vt=0.9 vh=0 ron=1 roff =100G"}
C {vsource.sym} -560 780 0 0 {name=Vdd1 value=1.8 savecurrent=false}
C {gnd.sym} -560 810 0 0 {name=l3 lab=GND}
C {lab_pin.sym} -560 750 1 0 {name=p107 sig_type=std_logic lab=vref}
C {lab_pin.sym} 660 0 0 1 {name=p111 sig_type=std_logic lab=comp_p}
C {lab_pin.sym} 660 190 0 1 {name=p112 sig_type=std_logic lab=comp_m}
C {sky130_stdcells/inv_8.sym} 1340 80 0 0 {name=x3 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} 1380 80 2 0 {name=p110 sig_type=std_logic lab=comp_out}
C {lab_pin.sym} -4030 -1070 0 0 {name=p1 sig_type=std_logic lab=clk}
C {lab_pin.sym} -4030 -1050 0 0 {name=p4 sig_type=std_logic lab=rst_n}
C {lab_pin.sym} -4030 -1030 0 0 {name=p5 sig_type=std_logic lab=comp_out}
C {lab_pin.sym} -3730 -1070 2 0 {name=p6 sig_type=std_logic lab=data_rdy}
C {lab_pin.sym} -3730 -1050 2 0 {name=p9 sig_type=std_logic lab=smpl}
C {lab_pin.sym} -3730 -1030 2 0 {name=p10 sig_type=std_logic lab=smpl_n}
C {lab_pin.sym} -3730 -990 2 0 {name=p13 sig_type=std_logic lab=supply}
C {lab_pin.sym} -3730 -970 2 0 {name=p14 sig_type=std_logic lab=data[7..0]}
C {lab_pin.sym} -3730 -950 2 0 {name=p17 sig_type=std_logic lab=data_n[7..0]}
C {gnd.sym} -3730 -1010 3 0 {name=l18 lab=GND}
C {vsource.sym} -650 780 0 0 {name=Vdd5 value=1.8 savecurrent=false}
C {gnd.sym} -650 810 0 0 {name=l19 lab=GND}
C {lab_pin.sym} -650 750 1 0 {name=p18 sig_type=std_logic lab=supply}
C {devices/vsource.sym} -1040 840 0 0 {name=V_VCM_2 value=0.9}
C {devices/gnd.sym} -1040 880 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -1040 800 0 0 {name=l11 sig_type=std_logic lab=vcm}
C {devices/vsource.sym} -1100 720 0 0 {name=V_VCM_1 value=0.1}
C {devices/vsource.sym} -980 720 2 1 {name=V_VCM_3 value=0.1}
C {lab_pin.sym} -980 690 1 0 {name=p21 sig_type=std_logic lab=vinm}
C {lab_pin.sym} -1100 690 1 0 {name=p22 sig_type=std_logic lab=vinp}
C {iopin.sym} 1180 60 0 0 {name=p25 lab=vdd}
C {iopin.sym} 1180 100 0 0 {name=p29 lab=vss}
C {lab_wire.sym} 860 60 0 0 {name=p34 sig_type=std_logic lab=ibn_1u

}
C {lab_pin.sym} 860 120 0 0 {name=p53 sig_type=std_logic lab=latch}
C {isource.sym} -1270 720 0 0 {name=I0 value=1u}
C {lab_wire.sym} -1270 680 1 0 {name=p46 sig_type=std_logic lab=vdd

}
C {lab_wire.sym} -1270 760 2 0 {name=p50 sig_type=std_logic lab=ibn_1u

}
C {lab_pin.sym} 260 710 0 0 {name=p58 sig_type=std_logic lab=clk}
C {sky130_stdcells/buf_1.sym} 300 710 0 0 {name=x68 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 500 710 0 0 {name=x70 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} 690 710 0 0 {name=x72 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} 740 710 2 0 {name=p62 sig_type=std_logic lab=latch}
C {sky130_fd_pr/nfet_01v8.sym} 350 780 1 0 {name=M27
L=5
W=5
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 380 810 0 0 {name=l4 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 550 780 1 0 {name=M1
L=5
W=5
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 580 810 0 0 {name=l5 lab=GND}
C {sky130_stdcells/buf_1.sym} 600 710 0 0 {name=x69 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {/home/shevi/whyRD_eda_bundle/sar_adc/8b-sar-adc-unic_cass-main/test/design/adc_comp.sym} 1020 90 0 0 {name=x1}
C {/home/shevi/whyRD_eda_bundle/sar_adc/8b-sar-adc-unic_cass-main/test/design/sar_controller.sym} -3880 -1010 0 0 {name=x2}
C {lab_pin.sym} -2920 -1080 0 0 {name=p54 sig_type=std_logic lab=data[7..0]}
C {lab_pin.sym} -2220 -900 3 0 {name=p57 sig_type=std_logic lab=d[7..0]}
C {sky130_stdcells/inv_2.sym} -2890 -1020 1 0 {name=x3[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/nor2_1.sym} -2670 -1060 0 0 {name=x4[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/nor2_1.sym} -2670 -900 0 0 {name=x5[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2530 -1060 0 0 {name=x6[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2410 -1060 0 0 {name=x7[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2300 -1060 0 0 {name=x8[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2530 -900 0 0 {name=x9[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2410 -900 0 0 {name=x10[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2300 -900 0 0 {name=x11[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -2150 -1060 0 0 {name=x13[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -2150 -900 0 0 {name=x14[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2110 -900 2 0 {name=p61 sig_type=std_logic lab=d_n[7..0]}
C {lab_pin.sym} -2220 -1060 3 0 {name=p65 sig_type=std_logic lab=dn[7..0]}
C {lab_pin.sym} -2110 -1060 2 0 {name=p66 sig_type=std_logic lab=dn_n[7..0]}
C {sky130_stdcells/or2_1.sym} -2090 -700 0 0 {name=x15[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -3430 -680 0 0 {name=p69 sig_type=std_logic lab=smpl}
C {sky130_stdcells/buf_1.sym} -3390 -680 0 0 {name=x7 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3300 -680 0 0 {name=x8 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3210 -680 0 0 {name=x9 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3120 -680 0 0 {name=x10 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3030 -680 0 0 {name=x11 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2940 -680 0 0 {name=x12 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2030 -700 1 0 {name=p70 sig_type=std_logic lab=phi1[7..0]}
C {sky130_stdcells/inv_2.sym} -1980 -700 0 0 {name=x16[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -1940 -700 2 0 {name=p71 sig_type=std_logic lab=phi1_n[7..0]}
C {sky130_stdcells/and2_2.sym} -2090 -1190 0 0 {name=x17[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2150 -1210 0 0 {name=p72 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} -2030 -1190 3 0 {name=p73 sig_type=std_logic lab=phi2[7..0]}
C {sky130_stdcells/buf_1.sym} -2830 -680 0 0 {name=x13 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2740 -680 0 0 {name=x14 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2650 -680 0 0 {name=x15 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2560 -680 0 0 {name=x16 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_2.sym} -2470 -680 0 0 {name=x17 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_4.sym} -2360 -680 0 0 {name=x35 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_6.sym} -2270 -680 0 0 {name=x36 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_8.sym} -1520 -600 0 0 {name=x37 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -1480 -600 2 0 {name=p74 sig_type=std_logic lab=smpl_n_d12}
C {sky130_stdcells/buf_1.sym} -2140 -600 0 0 {name=x38 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2050 -600 0 0 {name=x39 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -1960 -600 0 0 {name=x40 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_2.sym} -1870 -600 0 0 {name=x41 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_4.sym} -1760 -600 0 0 {name=x42 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_6.sym} -1670 -600 0 0 {name=x43 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -1940 -1190 0 0 {name=x18[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -1900 -1190 2 0 {name=p75 sig_type=std_logic lab=phi2_n[7..0]}
C {lab_pin.sym} -1240 -720 0 0 {name=p125 sig_type=std_logic lab=smpl}
C {lab_pin.sym} -1160 -720 2 0 {name=p126 sig_type=std_logic lab=smpl_out_n}
C {lab_pin.sym} -1240 -650 0 0 {name=p129 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} -1160 -650 2 0 {name=p130 sig_type=std_logic lab=smpl_n_d12_out_n}
C {sky130_stdcells/inv_8.sym} -1200 -720 0 0 {name=x44 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_8.sym} -1200 -650 0 0 {name=x45 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {capdac_switches.sym} 360 -180 0 0 {name=x4}
C {lab_pin.sym} 350 -310 1 0 {name=p31 sig_type=std_logic lab=vdd}
C {gnd.sym} 380 -310 3 0 {name=l16 lab=GND}
C {gnd.sym} 510 -250 3 0 {name=l17 lab=GND}
C {gnd.sym} 510 -230 3 0 {name=l20 lab=GND}
C {lab_pin.sym} 510 -210 2 0 {name=p48 sig_type=std_logic lab=vcm}
C {lab_pin.sym} 510 -170 2 0 {name=p51 sig_type=std_logic lab=vinp}
C {lab_pin.sym} 510 -190 2 0 {name=p52 sig_type=std_logic lab=vref}
C {lab_pin.sym} 220 -160 0 0 {name=p2 sig_type=std_logic lab=phi1[7..0]}
C {lab_pin.sym} 220 -140 0 0 {name=p3 sig_type=std_logic lab=phi1_n[7..0]}
C {lab_pin.sym} 220 -120 0 0 {name=p55 sig_type=std_logic lab=phi2[7..0]}
C {lab_pin.sym} 220 -100 0 0 {name=p56 sig_type=std_logic lab=phi2_n[7..0]}
C {lab_pin.sym} 220 -250 0 0 {name=p7 sig_type=std_logic lab=smpl}
C {lab_pin.sym} 220 -210 0 0 {name=p8 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} 220 -230 0 0 {name=p59 sig_type=std_logic lab=smpl_out_n}
C {lab_pin.sym} 220 -190 0 0 {name=p60 sig_type=std_logic lab=smpl_n_d12_out_n}
C {lab_pin.sym} 510 -140 2 0 {name=p11 sig_type=std_logic lab=smpl}
C {lab_pin.sym} 510 -100 2 0 {name=p12 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} 510 -120 2 0 {name=p15 sig_type=std_logic lab=smpl_out_n}
C {lab_pin.sym} 510 -80 2 0 {name=p16 sig_type=std_logic lab=smpl_n_d12_out_n}
C {capdac_switches.sym} 370 360 2 0 {name=x5}
C {lab_pin.sym} 380 490 3 0 {name=p19 sig_type=std_logic lab=vdd}
C {gnd.sym} 350 490 1 0 {name=l2 lab=GND}
C {gnd.sym} 220 430 1 0 {name=l8 lab=GND}
C {gnd.sym} 220 410 1 0 {name=l9 lab=GND}
C {lab_pin.sym} 220 390 0 0 {name=p20 sig_type=std_logic lab=vcm}
C {lab_pin.sym} 220 350 0 0 {name=p23 sig_type=std_logic lab=vinm}
C {lab_pin.sym} 220 370 0 0 {name=p24 sig_type=std_logic lab=vref}
C {lab_pin.sym} 510 340 2 0 {name=p26 sig_type=std_logic lab=phi1[7..0]}
C {lab_pin.sym} 510 320 2 0 {name=p27 sig_type=std_logic lab=phi1_n[7..0]}
C {lab_pin.sym} 510 300 2 0 {name=p28 sig_type=std_logic lab=phi2[7..0]}
C {lab_pin.sym} 510 280 2 0 {name=p30 sig_type=std_logic lab=phi2_n[7..0]}
C {lab_pin.sym} 220 320 0 0 {name=p32 sig_type=std_logic lab=smpl}
C {lab_pin.sym} 220 280 0 0 {name=p63 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} 220 300 0 0 {name=p64 sig_type=std_logic lab=smpl_out_n}
C {lab_pin.sym} 220 260 0 0 {name=p33 sig_type=std_logic lab=smpl_n_d12_out_n}
C {lab_pin.sym} 510 430 2 0 {name=p35 sig_type=std_logic lab=vdd}
C {gnd.sym} 510 410 3 0 {name=l14 lab=GND}
C {lab_pin.sym} 510 370 2 0 {name=p36 sig_type=std_logic lab=vdd}
C {gnd.sym} 510 390 3 0 {name=l21 lab=GND}
