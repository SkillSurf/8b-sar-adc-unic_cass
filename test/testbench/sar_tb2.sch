** sch_path: test/testbench/sar_tb2.sch
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice

**.subckt sar_tb2 vdd vss
*.iopin vdd
*.iopin vss
Vdd8 rst_n GND pulse(1.8 0 1n 1n 1n 50n 100u 1)
Vdd4 clk GND pulse(0 1.8 0.1n 0.1n 1n 500n 1u)
Vdd1 vref GND 1.8
x2 clk data_rdy sample rst_n sample_n comp_out GND supply data7 data6 data5 data4 data3 data2 data1
+ data0 data_n7 data_n6 data_n5 data_n4 data_n3 data_n2 data_n1 data_n0 sar_controller
Vdd5 supply GND 1.8
V_VCM_2 vcm GND 0.9
V_VCM_1 vinp vcm 0.1
V_VCM_3 vcm vinm 0.1
x1 vdd comp_out ibn_1u comp_p comp_m vss latch adc_comp
I0 vdd ibn_1u 1u
x2[7] data7 vss vss vcc vcc net1[7] sky130_fd_sc_hd__inv_2
x2[6] data6 vss vss vcc vcc net1[6] sky130_fd_sc_hd__inv_2
x2[5] data5 vss vss vcc vcc net1[5] sky130_fd_sc_hd__inv_2
x2[4] data4 vss vss vcc vcc net1[4] sky130_fd_sc_hd__inv_2
x2[3] data3 vss vss vcc vcc net1[3] sky130_fd_sc_hd__inv_2
x2[2] data2 vss vss vcc vcc net1[2] sky130_fd_sc_hd__inv_2
x2[1] data1 vss vss vcc vcc net1[1] sky130_fd_sc_hd__inv_2
x2[0] data0 vss vss vcc vcc net1[0] sky130_fd_sc_hd__inv_2
x6[7] data7 d7 vss vss vdd vdd net2[7] sky130_fd_sc_hd__nor2_1
x6[6] data6 d6 vss vss vdd vdd net2[6] sky130_fd_sc_hd__nor2_1
x6[5] data5 d5 vss vss vdd vdd net2[5] sky130_fd_sc_hd__nor2_1
x6[4] data4 d4 vss vss vdd vdd net2[4] sky130_fd_sc_hd__nor2_1
x6[3] data3 d3 vss vss vdd vdd net2[3] sky130_fd_sc_hd__nor2_1
x6[2] data2 d2 vss vss vdd vdd net2[2] sky130_fd_sc_hd__nor2_1
x6[1] data1 d1 vss vss vdd vdd net2[1] sky130_fd_sc_hd__nor2_1
x6[0] data0 d0 vss vss vdd vdd net2[0] sky130_fd_sc_hd__nor2_1
x16[7] dn7 net1[7] vss vss vdd vdd net5[7] sky130_fd_sc_hd__nor2_1
x16[6] dn6 net1[6] vss vss vdd vdd net5[6] sky130_fd_sc_hd__nor2_1
x16[5] dn5 net1[5] vss vss vdd vdd net5[5] sky130_fd_sc_hd__nor2_1
x16[4] dn4 net1[4] vss vss vdd vdd net5[4] sky130_fd_sc_hd__nor2_1
x16[3] dn3 net1[3] vss vss vdd vdd net5[3] sky130_fd_sc_hd__nor2_1
x16[2] dn2 net1[2] vss vss vdd vdd net5[2] sky130_fd_sc_hd__nor2_1
x16[1] dn1 net1[1] vss vss vdd vdd net5[1] sky130_fd_sc_hd__nor2_1
x16[0] dn0 net1[0] vss vss vdd vdd net5[0] sky130_fd_sc_hd__nor2_1
x17[7] net2[7] vss vss vdd vdd net3[7] sky130_fd_sc_hd__buf_1
x17[6] net2[6] vss vss vdd vdd net3[6] sky130_fd_sc_hd__buf_1
x17[5] net2[5] vss vss vdd vdd net3[5] sky130_fd_sc_hd__buf_1
x17[4] net2[4] vss vss vdd vdd net3[4] sky130_fd_sc_hd__buf_1
x17[3] net2[3] vss vss vdd vdd net3[3] sky130_fd_sc_hd__buf_1
x17[2] net2[2] vss vss vdd vdd net3[2] sky130_fd_sc_hd__buf_1
x17[1] net2[1] vss vss vdd vdd net3[1] sky130_fd_sc_hd__buf_1
x17[0] net2[0] vss vss vdd vdd net3[0] sky130_fd_sc_hd__buf_1
x35[7] net3[7] vss vss vdd vdd net4[7] sky130_fd_sc_hd__buf_2
x35[6] net3[6] vss vss vdd vdd net4[6] sky130_fd_sc_hd__buf_2
x35[5] net3[5] vss vss vdd vdd net4[5] sky130_fd_sc_hd__buf_2
x35[4] net3[4] vss vss vdd vdd net4[4] sky130_fd_sc_hd__buf_2
x35[3] net3[3] vss vss vdd vdd net4[3] sky130_fd_sc_hd__buf_2
x35[2] net3[2] vss vss vdd vdd net4[2] sky130_fd_sc_hd__buf_2
x35[1] net3[1] vss vss vdd vdd net4[1] sky130_fd_sc_hd__buf_2
x35[0] net3[0] vss vss vdd vdd net4[0] sky130_fd_sc_hd__buf_2
x36[7] net4[7] vss vss vdd vdd dn7 sky130_fd_sc_hd__buf_1
x36[6] net4[6] vss vss vdd vdd dn6 sky130_fd_sc_hd__buf_1
x36[5] net4[5] vss vss vdd vdd dn5 sky130_fd_sc_hd__buf_1
x36[4] net4[4] vss vss vdd vdd dn4 sky130_fd_sc_hd__buf_1
x36[3] net4[3] vss vss vdd vdd dn3 sky130_fd_sc_hd__buf_1
x36[2] net4[2] vss vss vdd vdd dn2 sky130_fd_sc_hd__buf_1
x36[1] net4[1] vss vss vdd vdd dn1 sky130_fd_sc_hd__buf_1
x36[0] net4[0] vss vss vdd vdd dn0 sky130_fd_sc_hd__buf_1
x37[7] net5[7] vss vss vdd vdd net6[7] sky130_fd_sc_hd__buf_1
x37[6] net5[6] vss vss vdd vdd net6[6] sky130_fd_sc_hd__buf_1
x37[5] net5[5] vss vss vdd vdd net6[5] sky130_fd_sc_hd__buf_1
x37[4] net5[4] vss vss vdd vdd net6[4] sky130_fd_sc_hd__buf_1
x37[3] net5[3] vss vss vdd vdd net6[3] sky130_fd_sc_hd__buf_1
x37[2] net5[2] vss vss vdd vdd net6[2] sky130_fd_sc_hd__buf_1
x37[1] net5[1] vss vss vdd vdd net6[1] sky130_fd_sc_hd__buf_1
x37[0] net5[0] vss vss vdd vdd net6[0] sky130_fd_sc_hd__buf_1
x38[7] net6[7] vss vss vdd vdd net7[7] sky130_fd_sc_hd__buf_2
x38[6] net6[6] vss vss vdd vdd net7[6] sky130_fd_sc_hd__buf_2
x38[5] net6[5] vss vss vdd vdd net7[5] sky130_fd_sc_hd__buf_2
x38[4] net6[4] vss vss vdd vdd net7[4] sky130_fd_sc_hd__buf_2
x38[3] net6[3] vss vss vdd vdd net7[3] sky130_fd_sc_hd__buf_2
x38[2] net6[2] vss vss vdd vdd net7[2] sky130_fd_sc_hd__buf_2
x38[1] net6[1] vss vss vdd vdd net7[1] sky130_fd_sc_hd__buf_2
x38[0] net6[0] vss vss vdd vdd net7[0] sky130_fd_sc_hd__buf_2
x39[7] net7[7] vss vss vdd vdd d7 sky130_fd_sc_hd__buf_1
x39[6] net7[6] vss vss vdd vdd d6 sky130_fd_sc_hd__buf_1
x39[5] net7[5] vss vss vdd vdd d5 sky130_fd_sc_hd__buf_1
x39[4] net7[4] vss vss vdd vdd d4 sky130_fd_sc_hd__buf_1
x39[3] net7[3] vss vss vdd vdd d3 sky130_fd_sc_hd__buf_1
x39[2] net7[2] vss vss vdd vdd d2 sky130_fd_sc_hd__buf_1
x39[1] net7[1] vss vss vdd vdd d1 sky130_fd_sc_hd__buf_1
x39[0] net7[0] vss vss vdd vdd d0 sky130_fd_sc_hd__buf_1
x5[7] d7 sphi1 vss vss vcc vcc net8 sky130_fd_sc_hd__or2_2
x1[6] sample_n dn6 vss vss vcc vcc net34[6] sky130_fd_sc_hd__and2_2
x1[5] sample_n dn5 vss vss vcc vcc net34[5] sky130_fd_sc_hd__and2_2
x1[4] sample_n dn4 vss vss vcc vcc net34[4] sky130_fd_sc_hd__and2_2
x1[3] sample_n dn3 vss vss vcc vcc net34[3] sky130_fd_sc_hd__and2_2
x1[2] sample_n dn2 vss vss vcc vcc net34[2] sky130_fd_sc_hd__and2_2
x1[1] sample_n dn1 vss vss vcc vcc net34[1] sky130_fd_sc_hd__and2_2
x1[0] sample_n dn0 vss vss vcc vcc net34[0] sky130_fd_sc_hd__and2_2
x42 clk vss vss vdd vdd net9 sky130_fd_sc_hd__buf_1
x43 net9 vss vss vdd vdd net10 sky130_fd_sc_hd__buf_1
x44 net11 vss vss vcc vcc latch sky130_fd_sc_hd__inv_2
XM2 GND net9 GND GND sky130_fd_pr__nfet_01v8 L=5 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
XM3 GND net10 GND GND sky130_fd_pr__nfet_01v8 L=5 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=2 m=2
x45 net10 vss vss vdd vdd net11 sky130_fd_sc_hd__buf_1
x46 sample vss vss vcc vcc net12 sky130_fd_sc_hd__inv_2
x47 sample net14 vss vss vdd vdd net15 sky130_fd_sc_hd__nor2_1
x48 net13 net12 vss vss vdd vdd net19 sky130_fd_sc_hd__nor2_1
x49 net15 vss vss vdd vdd net16 sky130_fd_sc_hd__buf_1
x50 net16 vss vss vdd vdd net17 sky130_fd_sc_hd__buf_6
x51 net17 vss vss vdd vdd net18 sky130_fd_sc_hd__buf_1
x52 net19 vss vss vdd vdd net20 sky130_fd_sc_hd__buf_1
x53 net20 vss vss vdd vdd net21 sky130_fd_sc_hd__buf_6
x54 net21 vss vss vdd vdd net22 sky130_fd_sc_hd__buf_1
x55 net18 vss vss vdd vdd net26 sky130_fd_sc_hd__buf_6
x56 net22 vss vss vdd vdd net24 sky130_fd_sc_hd__buf_6
x41[6] d6 sample vss vss vcc vcc net23[6] sky130_fd_sc_hd__or2_2
x41[5] d5 sample vss vss vcc vcc net23[5] sky130_fd_sc_hd__or2_2
x41[4] d4 sample vss vss vcc vcc net23[4] sky130_fd_sc_hd__or2_2
x41[3] d3 sample vss vss vcc vcc net23[3] sky130_fd_sc_hd__or2_2
x41[2] d2 sample vss vss vcc vcc net23[2] sky130_fd_sc_hd__or2_2
x41[1] d1 sample vss vss vcc vcc net23[1] sky130_fd_sc_hd__or2_2
x41[0] d0 sample vss vss vcc vcc net23[0] sky130_fd_sc_hd__or2_2
x57 sphi2 dn7 vss vss vcc vcc net35 sky130_fd_sc_hd__and2_2
x58 net24 vss vss vdd vdd net25 sky130_fd_sc_hd__buf_1
x59 net25 vss vss vdd vdd net28 sky130_fd_sc_hd__buf_6
x60 net26 vss vss vdd vdd net27 sky130_fd_sc_hd__buf_1
x61 net27 vss vss vdd vdd net30 sky130_fd_sc_hd__buf_6
x62 net28 vss vss vdd vdd net29 sky130_fd_sc_hd__buf_1
x63 net29 vss vss vdd vdd net14 sky130_fd_sc_hd__buf_4
x64 net30 vss vss vdd vdd net31 sky130_fd_sc_hd__buf_1
x65 net31 vss vss vdd vdd net13 sky130_fd_sc_hd__buf_4
x43[7] d7 vss vss vdd vdd net36[7] sky130_fd_sc_hd__buf_1
x43[6] d6 vss vss vdd vdd net36[6] sky130_fd_sc_hd__buf_1
x43[5] d5 vss vss vdd vdd net36[5] sky130_fd_sc_hd__buf_1
x43[4] d4 vss vss vdd vdd net36[4] sky130_fd_sc_hd__buf_1
x43[3] d3 vss vss vdd vdd net36[3] sky130_fd_sc_hd__buf_1
x43[2] d2 vss vss vdd vdd net36[2] sky130_fd_sc_hd__buf_1
x43[1] d1 vss vss vdd vdd net36[1] sky130_fd_sc_hd__buf_1
x43[0] d0 vss vss vdd vdd net36[0] sky130_fd_sc_hd__buf_1
x44[7] net36[7] vss vss vdd vdd net37[7] sky130_fd_sc_hd__buf_2
x44[6] net36[6] vss vss vdd vdd net37[6] sky130_fd_sc_hd__buf_2
x44[5] net36[5] vss vss vdd vdd net37[5] sky130_fd_sc_hd__buf_2
x44[4] net36[4] vss vss vdd vdd net37[4] sky130_fd_sc_hd__buf_2
x44[3] net36[3] vss vss vdd vdd net37[3] sky130_fd_sc_hd__buf_2
x44[2] net36[2] vss vss vdd vdd net37[2] sky130_fd_sc_hd__buf_2
x44[1] net36[1] vss vss vdd vdd net37[1] sky130_fd_sc_hd__buf_2
x44[0] net36[0] vss vss vdd vdd net37[0] sky130_fd_sc_hd__buf_2
x45[7] net37[7] vss vss vdd vdd net38[7] sky130_fd_sc_hd__buf_4
x45[6] net37[6] vss vss vdd vdd net38[6] sky130_fd_sc_hd__buf_4
x45[5] net37[5] vss vss vdd vdd net38[5] sky130_fd_sc_hd__buf_4
x45[4] net37[4] vss vss vdd vdd net38[4] sky130_fd_sc_hd__buf_4
x45[3] net37[3] vss vss vdd vdd net38[3] sky130_fd_sc_hd__buf_4
x45[2] net37[2] vss vss vdd vdd net38[2] sky130_fd_sc_hd__buf_4
x45[1] net37[1] vss vss vdd vdd net38[1] sky130_fd_sc_hd__buf_4
x45[0] net37[0] vss vss vdd vdd net38[0] sky130_fd_sc_hd__buf_4
x46[7] net38[7] vss vss vdd vdd phi17 sky130_fd_sc_hd__buf_8
x46[6] net38[6] vss vss vdd vdd phi16 sky130_fd_sc_hd__buf_8
x46[5] net38[5] vss vss vdd vdd phi15 sky130_fd_sc_hd__buf_8
x46[4] net38[4] vss vss vdd vdd phi14 sky130_fd_sc_hd__buf_8
x46[3] net38[3] vss vss vdd vdd phi13 sky130_fd_sc_hd__buf_8
x46[2] net38[2] vss vss vdd vdd phi12 sky130_fd_sc_hd__buf_8
x46[1] net38[1] vss vss vdd vdd phi11 sky130_fd_sc_hd__buf_8
x46[0] net38[0] vss vss vdd vdd phi10 sky130_fd_sc_hd__buf_8
x47[7] dn7 vss vss vdd vdd net39[7] sky130_fd_sc_hd__buf_1
x47[6] dn6 vss vss vdd vdd net39[6] sky130_fd_sc_hd__buf_1
x47[5] dn5 vss vss vdd vdd net39[5] sky130_fd_sc_hd__buf_1
x47[4] dn4 vss vss vdd vdd net39[4] sky130_fd_sc_hd__buf_1
x47[3] dn3 vss vss vdd vdd net39[3] sky130_fd_sc_hd__buf_1
x47[2] dn2 vss vss vdd vdd net39[2] sky130_fd_sc_hd__buf_1
x47[1] dn1 vss vss vdd vdd net39[1] sky130_fd_sc_hd__buf_1
x47[0] dn0 vss vss vdd vdd net39[0] sky130_fd_sc_hd__buf_1
x48[7] net39[7] vss vss vdd vdd net40[7] sky130_fd_sc_hd__buf_2
x48[6] net39[6] vss vss vdd vdd net40[6] sky130_fd_sc_hd__buf_2
x48[5] net39[5] vss vss vdd vdd net40[5] sky130_fd_sc_hd__buf_2
x48[4] net39[4] vss vss vdd vdd net40[4] sky130_fd_sc_hd__buf_2
x48[3] net39[3] vss vss vdd vdd net40[3] sky130_fd_sc_hd__buf_2
x48[2] net39[2] vss vss vdd vdd net40[2] sky130_fd_sc_hd__buf_2
x48[1] net39[1] vss vss vdd vdd net40[1] sky130_fd_sc_hd__buf_2
x48[0] net39[0] vss vss vdd vdd net40[0] sky130_fd_sc_hd__buf_2
x49[7] net40[7] vss vss vdd vdd net41[7] sky130_fd_sc_hd__buf_4
x49[6] net40[6] vss vss vdd vdd net41[6] sky130_fd_sc_hd__buf_4
x49[5] net40[5] vss vss vdd vdd net41[5] sky130_fd_sc_hd__buf_4
x49[4] net40[4] vss vss vdd vdd net41[4] sky130_fd_sc_hd__buf_4
x49[3] net40[3] vss vss vdd vdd net41[3] sky130_fd_sc_hd__buf_4
x49[2] net40[2] vss vss vdd vdd net41[2] sky130_fd_sc_hd__buf_4
x49[1] net40[1] vss vss vdd vdd net41[1] sky130_fd_sc_hd__buf_4
x49[0] net40[0] vss vss vdd vdd net41[0] sky130_fd_sc_hd__buf_4
x50[7] net41[7] vss vss vdd vdd phi27 sky130_fd_sc_hd__buf_8
x50[6] net41[6] vss vss vdd vdd phi26 sky130_fd_sc_hd__buf_8
x50[5] net41[5] vss vss vdd vdd phi25 sky130_fd_sc_hd__buf_8
x50[4] net41[4] vss vss vdd vdd phi24 sky130_fd_sc_hd__buf_8
x50[3] net41[3] vss vss vdd vdd phi23 sky130_fd_sc_hd__buf_8
x50[2] net41[2] vss vss vdd vdd phi22 sky130_fd_sc_hd__buf_8
x50[1] net41[1] vss vss vdd vdd phi21 sky130_fd_sc_hd__buf_8
x50[0] net41[0] vss vss vdd vdd phi20 sky130_fd_sc_hd__buf_8
x51[7] phi27 vss vss vdd vdd phi2_n7 sky130_fd_sc_hd__inv_8
x51[6] phi26 vss vss vdd vdd phi2_n6 sky130_fd_sc_hd__inv_8
x51[5] phi25 vss vss vdd vdd phi2_n5 sky130_fd_sc_hd__inv_8
x51[4] phi24 vss vss vdd vdd phi2_n4 sky130_fd_sc_hd__inv_8
x51[3] phi23 vss vss vdd vdd phi2_n3 sky130_fd_sc_hd__inv_8
x51[2] phi22 vss vss vdd vdd phi2_n2 sky130_fd_sc_hd__inv_8
x51[1] phi21 vss vss vdd vdd phi2_n1 sky130_fd_sc_hd__inv_8
x51[0] phi20 vss vss vdd vdd phi2_n0 sky130_fd_sc_hd__inv_8
x52[7] phi17 vss vss vdd vdd phi1_n7 sky130_fd_sc_hd__inv_8
x52[6] phi16 vss vss vdd vdd phi1_n6 sky130_fd_sc_hd__inv_8
x52[5] phi15 vss vss vdd vdd phi1_n5 sky130_fd_sc_hd__inv_8
x52[4] phi14 vss vss vdd vdd phi1_n4 sky130_fd_sc_hd__inv_8
x52[3] phi13 vss vss vdd vdd phi1_n3 sky130_fd_sc_hd__inv_8
x52[2] phi12 vss vss vdd vdd phi1_n2 sky130_fd_sc_hd__inv_8
x52[1] phi11 vss vss vdd vdd phi1_n1 sky130_fd_sc_hd__inv_8
x52[0] phi10 vss vss vdd vdd phi1_n0 sky130_fd_sc_hd__inv_8
x66 net8 vss vss vdd vdd net42 sky130_fd_sc_hd__buf_1
x67 net42 vss vss vdd vdd net43 sky130_fd_sc_hd__buf_2
x71 net43 vss vss vdd vdd net44 sky130_fd_sc_hd__buf_4
x73 net44 vss vss vdd vdd phi1x7 sky130_fd_sc_hd__buf_8
x53[6] net23[6] vss vss vdd vdd net45[6] sky130_fd_sc_hd__buf_1
x53[5] net23[5] vss vss vdd vdd net45[5] sky130_fd_sc_hd__buf_1
x53[4] net23[4] vss vss vdd vdd net45[4] sky130_fd_sc_hd__buf_1
x53[3] net23[3] vss vss vdd vdd net45[3] sky130_fd_sc_hd__buf_1
x53[2] net23[2] vss vss vdd vdd net45[2] sky130_fd_sc_hd__buf_1
x53[1] net23[1] vss vss vdd vdd net45[1] sky130_fd_sc_hd__buf_1
x53[0] net23[0] vss vss vdd vdd net45[0] sky130_fd_sc_hd__buf_1
x54[6] net45[6] vss vss vdd vdd net46[6] sky130_fd_sc_hd__buf_2
x54[5] net45[5] vss vss vdd vdd net46[5] sky130_fd_sc_hd__buf_2
x54[4] net45[4] vss vss vdd vdd net46[4] sky130_fd_sc_hd__buf_2
x54[3] net45[3] vss vss vdd vdd net46[3] sky130_fd_sc_hd__buf_2
x54[2] net45[2] vss vss vdd vdd net46[2] sky130_fd_sc_hd__buf_2
x54[1] net45[1] vss vss vdd vdd net46[1] sky130_fd_sc_hd__buf_2
x54[0] net45[0] vss vss vdd vdd net46[0] sky130_fd_sc_hd__buf_2
x55[6] net46[6] vss vss vdd vdd net47[6] sky130_fd_sc_hd__buf_4
x55[5] net46[5] vss vss vdd vdd net47[5] sky130_fd_sc_hd__buf_4
x55[4] net46[4] vss vss vdd vdd net47[4] sky130_fd_sc_hd__buf_4
x55[3] net46[3] vss vss vdd vdd net47[3] sky130_fd_sc_hd__buf_4
x55[2] net46[2] vss vss vdd vdd net47[2] sky130_fd_sc_hd__buf_4
x55[1] net46[1] vss vss vdd vdd net47[1] sky130_fd_sc_hd__buf_4
x55[0] net46[0] vss vss vdd vdd net47[0] sky130_fd_sc_hd__buf_4
x56[6] net47[6] vss vss vdd vdd phi1x6 sky130_fd_sc_hd__buf_8
x56[5] net47[5] vss vss vdd vdd phi1x5 sky130_fd_sc_hd__buf_8
x56[4] net47[4] vss vss vdd vdd phi1x4 sky130_fd_sc_hd__buf_8
x56[3] net47[3] vss vss vdd vdd phi1x3 sky130_fd_sc_hd__buf_8
x56[2] net47[2] vss vss vdd vdd phi1x2 sky130_fd_sc_hd__buf_8
x56[1] net47[1] vss vss vdd vdd phi1x1 sky130_fd_sc_hd__buf_8
x56[0] net47[0] vss vss vdd vdd phi1x0 sky130_fd_sc_hd__buf_8
x57[6] net34[6] vss vss vdd vdd net48[6] sky130_fd_sc_hd__buf_1
x57[5] net34[5] vss vss vdd vdd net48[5] sky130_fd_sc_hd__buf_1
x57[4] net34[4] vss vss vdd vdd net48[4] sky130_fd_sc_hd__buf_1
x57[3] net34[3] vss vss vdd vdd net48[3] sky130_fd_sc_hd__buf_1
x57[2] net34[2] vss vss vdd vdd net48[2] sky130_fd_sc_hd__buf_1
x57[1] net34[1] vss vss vdd vdd net48[1] sky130_fd_sc_hd__buf_1
x57[0] net34[0] vss vss vdd vdd net48[0] sky130_fd_sc_hd__buf_1
x58[6] net48[6] vss vss vdd vdd net49[6] sky130_fd_sc_hd__buf_2
x58[5] net48[5] vss vss vdd vdd net49[5] sky130_fd_sc_hd__buf_2
x58[4] net48[4] vss vss vdd vdd net49[4] sky130_fd_sc_hd__buf_2
x58[3] net48[3] vss vss vdd vdd net49[3] sky130_fd_sc_hd__buf_2
x58[2] net48[2] vss vss vdd vdd net49[2] sky130_fd_sc_hd__buf_2
x58[1] net48[1] vss vss vdd vdd net49[1] sky130_fd_sc_hd__buf_2
x58[0] net48[0] vss vss vdd vdd net49[0] sky130_fd_sc_hd__buf_2
x59[6] net49[6] vss vss vdd vdd net50[6] sky130_fd_sc_hd__buf_4
x59[5] net49[5] vss vss vdd vdd net50[5] sky130_fd_sc_hd__buf_4
x59[4] net49[4] vss vss vdd vdd net50[4] sky130_fd_sc_hd__buf_4
x59[3] net49[3] vss vss vdd vdd net50[3] sky130_fd_sc_hd__buf_4
x59[2] net49[2] vss vss vdd vdd net50[2] sky130_fd_sc_hd__buf_4
x59[1] net49[1] vss vss vdd vdd net50[1] sky130_fd_sc_hd__buf_4
x59[0] net49[0] vss vss vdd vdd net50[0] sky130_fd_sc_hd__buf_4
x60[6] net50[6] vss vss vdd vdd phi2x6 sky130_fd_sc_hd__buf_8
x60[5] net50[5] vss vss vdd vdd phi2x5 sky130_fd_sc_hd__buf_8
x60[4] net50[4] vss vss vdd vdd phi2x4 sky130_fd_sc_hd__buf_8
x60[3] net50[3] vss vss vdd vdd phi2x3 sky130_fd_sc_hd__buf_8
x60[2] net50[2] vss vss vdd vdd phi2x2 sky130_fd_sc_hd__buf_8
x60[1] net50[1] vss vss vdd vdd phi2x1 sky130_fd_sc_hd__buf_8
x60[0] net50[0] vss vss vdd vdd phi2x0 sky130_fd_sc_hd__buf_8
x74 net35 vss vss vdd vdd net51 sky130_fd_sc_hd__buf_1
x75 net51 vss vss vdd vdd net52 sky130_fd_sc_hd__buf_2
x76 net52 vss vss vdd vdd net53 sky130_fd_sc_hd__buf_4
x78 net53 vss vss vdd vdd phi2x7 sky130_fd_sc_hd__buf_8
x79 phi2x7 vss vss vdd vdd phi2x_n7 sky130_fd_sc_hd__inv_8
x61[6] phi2x6 vss vss vdd vdd phi2x_n6 sky130_fd_sc_hd__inv_8
x61[5] phi2x5 vss vss vdd vdd phi2x_n5 sky130_fd_sc_hd__inv_8
x61[4] phi2x4 vss vss vdd vdd phi2x_n4 sky130_fd_sc_hd__inv_8
x61[3] phi2x3 vss vss vdd vdd phi2x_n3 sky130_fd_sc_hd__inv_8
x61[2] phi2x2 vss vss vdd vdd phi2x_n2 sky130_fd_sc_hd__inv_8
x61[1] phi2x1 vss vss vdd vdd phi2x_n1 sky130_fd_sc_hd__inv_8
x61[0] phi2x0 vss vss vdd vdd phi2x_n0 sky130_fd_sc_hd__inv_8
x80 phi1x7 vss vss vdd vdd phi1x_n7 sky130_fd_sc_hd__inv_8
x62[6] phi1x6 vss vss vdd vdd phi1x_n6 sky130_fd_sc_hd__inv_8
x62[5] phi1x5 vss vss vdd vdd phi1x_n5 sky130_fd_sc_hd__inv_8
x62[4] phi1x4 vss vss vdd vdd phi1x_n4 sky130_fd_sc_hd__inv_8
x62[3] phi1x3 vss vss vdd vdd phi1x_n3 sky130_fd_sc_hd__inv_8
x62[2] phi1x2 vss vss vdd vdd phi1x_n2 sky130_fd_sc_hd__inv_8
x62[1] phi1x1 vss vss vdd vdd phi1x_n1 sky130_fd_sc_hd__inv_8
x62[0] phi1x0 vss vss vdd vdd phi1x_n0 sky130_fd_sc_hd__inv_8
x81 net14 vss vss vdd vdd net54 sky130_fd_sc_hd__buf_1
x82 net54 vss vss vdd vdd net55 sky130_fd_sc_hd__buf_2
x83 net55 vss vss vdd vdd net56 sky130_fd_sc_hd__buf_4
x84 net56 vss vss vdd vdd sphi1 sky130_fd_sc_hd__buf_8
x85 net13 vss vss vdd vdd net57 sky130_fd_sc_hd__buf_1
x86 net57 vss vss vdd vdd net58 sky130_fd_sc_hd__buf_2
x87 net58 vss vss vdd vdd net59 sky130_fd_sc_hd__buf_4
x88 net59 vss vss vdd vdd sphi2 sky130_fd_sc_hd__buf_8
x89 sphi1 vss vss vdd vdd sphi1_n sky130_fd_sc_hd__inv_8
x90 sphi2 vss vss vdd vdd sphi2_n sky130_fd_sc_hd__inv_8
x3 net32 sub GND vdd sphi1 sphi2 sphi2_n sphi1_n comp_p cap_switch_block
x4 net32 sub GND vdd phi1x0 phi2x0 phi2x_n0 phi1x_n0 comp_p cap_switch_block
x12 net32 sub GND vdd phi1x1 phi2x1 phi2x_n1 phi1x_n1 comp_p cap_switch_block
x11 net32 sub GND vdd phi1x1 phi2x1 phi2x_n1 phi1x_n1 comp_p cap_switch_block
x24 net32 sub GND vdd phi1x2 phi2x2 phi2x_n2 phi1x_n2 comp_p cap_switch_block
x23 net32 sub GND vdd phi1x2 phi2x2 phi2x_n2 phi1x_n2 comp_p cap_switch_block
x22 net32 sub GND vdd phi1x2 phi2x2 phi2x_n2 phi1x_n2 comp_p cap_switch_block
x21 net32 sub GND vdd phi1x2 phi2x2 phi2x_n2 phi1x_n2 comp_p cap_switch_block
x38 net32 sub GND vdd phi1x3 phi2x3 phi2x_n3 phi1x_n3 comp_p cap_switch_block
x37 net32 sub GND vdd phi1x3 phi2x3 phi2x_n3 phi1x_n3 comp_p cap_switch_block
x36 net32 sub GND vdd phi1x3 phi2x3 phi2x_n3 phi1x_n3 comp_p cap_switch_block
x35 net32 sub GND vdd phi1x3 phi2x3 phi2x_n3 phi1x_n3 comp_p cap_switch_block
x34 net32 sub GND vdd phi1x3 phi2x3 phi2x_n3 phi1x_n3 comp_p cap_switch_block
x33 net32 sub GND vdd phi1x3 phi2x3 phi2x_n3 phi1x_n3 comp_p cap_switch_block
x32 net32 sub GND vdd phi1x3 phi2x3 phi2x_n3 phi1x_n3 comp_p cap_switch_block
x31 net32 sub GND vdd phi1x3 phi2x3 phi2x_n3 phi1x_n3 comp_p cap_switch_block
x916 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x915 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x914 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x913 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x912 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x911 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x910 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x99 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x98 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x97 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x96 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x95 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x94 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x93 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x92 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x91 net32 sub GND vdd phi1x4 phi2x4 phi2x_n4 phi1x_n4 comp_p cap_switch_block
x1032 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1031 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1030 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1029 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1028 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1027 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1026 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1025 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1024 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1023 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1022 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1021 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1020 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1019 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1018 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1017 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1016 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1015 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1014 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1013 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1012 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1011 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1010 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x109 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x108 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x107 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x106 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x105 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x104 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x103 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x102 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x101 net32 sub GND vdd phi1x5 phi2x5 phi2x_n5 phi1x_n5 comp_p cap_switch_block
x1164 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1163 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1162 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1161 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1160 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1159 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1158 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1157 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1156 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1155 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1154 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1153 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1152 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1151 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1150 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1149 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1148 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1147 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1146 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1145 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1144 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1143 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1142 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1141 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1140 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1139 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1138 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1137 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1136 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1135 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1134 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1133 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1132 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1131 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1130 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1129 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1128 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1127 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1126 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1125 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1124 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1123 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1122 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1121 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1120 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1119 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1118 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1117 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1116 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1115 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1114 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1113 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1112 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1111 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x1110 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x119 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x118 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x117 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x116 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x115 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x114 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x113 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x112 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x111 net32 sub GND vdd phi1x6 phi2x6 phi2x_n6 phi1x_n6 comp_p cap_switch_block
x12128 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12127 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12126 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12125 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12124 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12123 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12122 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12121 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12120 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12119 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12118 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12117 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12116 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12115 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12114 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12113 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12112 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12111 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12110 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12109 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12108 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12107 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12106 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12105 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12104 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12103 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12102 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12101 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x12100 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1299 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1298 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1297 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1296 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1295 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1294 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1293 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1292 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1291 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1290 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1289 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1288 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1287 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1286 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1285 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1284 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1283 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1282 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1281 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1280 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1279 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1278 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1277 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1276 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1275 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1274 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1273 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1272 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1271 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1270 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1269 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1268 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1267 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1266 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1265 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1264 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1263 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1262 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1261 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1260 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1259 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1258 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1257 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1256 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1255 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1254 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1253 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1252 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1251 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1250 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1249 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1248 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1247 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1246 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1245 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1244 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1243 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1242 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1241 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1240 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1239 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1238 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1237 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1236 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1235 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1234 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1233 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1232 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1231 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1230 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1229 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1228 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1227 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1226 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1225 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1224 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1223 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1222 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1221 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1220 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1219 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1218 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1217 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1216 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1215 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1214 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1213 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1212 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1211 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x1210 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x129 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x128 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x127 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x126 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x125 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x124 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x123 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x122 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x121 net32 sub GND vdd phi1x7 phi2x7 phi2x_n7 phi1x_n7 comp_p cap_switch_block
x5 net33 sub net33 vdd sphi1 sphi2 sphi2_n sphi1_n comp_m cap_switch_block
x6 net33 sub GND vdd phi20 phi10 phi1_n0 phi2_n0 comp_m cap_switch_block
x132 net33 sub GND vdd phi21 phi11 phi1_n1 phi2_n1 comp_m cap_switch_block
x131 net33 sub GND vdd phi21 phi11 phi1_n1 phi2_n1 comp_m cap_switch_block
x144 net33 sub GND vdd phi22 phi12 phi1_n2 phi2_n2 comp_m cap_switch_block
x143 net33 sub GND vdd phi22 phi12 phi1_n2 phi2_n2 comp_m cap_switch_block
x142 net33 sub GND vdd phi22 phi12 phi1_n2 phi2_n2 comp_m cap_switch_block
x141 net33 sub GND vdd phi22 phi12 phi1_n2 phi2_n2 comp_m cap_switch_block
x158 net33 sub GND vdd phi23 phi13 phi1_n3 phi2_n3 comp_m cap_switch_block
x157 net33 sub GND vdd phi23 phi13 phi1_n3 phi2_n3 comp_m cap_switch_block
x156 net33 sub GND vdd phi23 phi13 phi1_n3 phi2_n3 comp_m cap_switch_block
x155 net33 sub GND vdd phi23 phi13 phi1_n3 phi2_n3 comp_m cap_switch_block
x154 net33 sub GND vdd phi23 phi13 phi1_n3 phi2_n3 comp_m cap_switch_block
x153 net33 sub GND vdd phi23 phi13 phi1_n3 phi2_n3 comp_m cap_switch_block
x152 net33 sub GND vdd phi23 phi13 phi1_n3 phi2_n3 comp_m cap_switch_block
x151 net33 sub GND vdd phi23 phi13 phi1_n3 phi2_n3 comp_m cap_switch_block
x1616 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x1615 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x1614 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x1613 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x1612 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x1611 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x1610 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x169 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x168 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x167 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x166 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x165 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x164 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x163 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x162 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x161 net33 sub GND vdd phi24 phi14 phi1_n4 phi2_n4 comp_m cap_switch_block
x1732 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1731 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1730 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1729 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1728 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1727 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1726 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1725 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1724 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1723 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1722 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1721 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1720 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1719 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1718 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1717 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1716 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1715 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1714 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1713 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1712 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1711 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1710 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x179 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x178 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x177 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x176 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x175 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x174 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x173 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x172 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x171 net33 sub GND vdd phi25 phi15 phi1_n5 phi2_n5 comp_m cap_switch_block
x1864 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1863 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1862 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1861 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1860 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1859 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1858 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1857 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1856 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1855 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1854 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1853 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1852 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1851 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1850 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1849 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1848 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1847 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1846 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1845 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1844 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1843 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1842 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1841 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1840 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1839 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1838 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1837 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1836 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1835 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1834 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1833 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1832 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1831 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1830 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1829 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1828 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1827 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1826 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1825 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1824 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1823 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1822 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1821 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1820 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1819 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1818 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1817 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1816 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1815 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1814 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1813 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1812 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1811 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x1810 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x189 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x188 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x187 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x186 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x185 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x184 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x183 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x182 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x181 net33 sub GND vdd phi26 phi16 phi1_n6 phi2_n6 comp_m cap_switch_block
x19128 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19127 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19126 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19125 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19124 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19123 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19122 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19121 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19120 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19119 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19118 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19117 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19116 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19115 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19114 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19113 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19112 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19111 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19110 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19109 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19108 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19107 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19106 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19105 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19104 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19103 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19102 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19101 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x19100 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1999 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1998 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1997 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1996 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1995 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1994 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1993 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1992 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1991 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1990 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1989 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1988 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1987 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1986 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1985 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1984 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1983 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1982 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1981 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1980 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1979 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1978 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1977 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1976 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1975 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1974 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1973 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1972 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1971 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1970 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1969 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1968 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1967 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1966 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1965 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1964 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1963 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1962 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1961 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1960 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1959 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1958 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1957 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1956 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1955 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1954 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1953 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1952 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1951 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1950 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1949 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1948 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1947 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1946 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1945 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1944 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1943 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1942 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1941 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1940 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1939 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1938 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1937 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1936 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1935 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1934 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1933 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1932 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1931 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1930 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1929 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1928 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1927 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1926 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1925 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1924 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1923 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1922 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1921 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1920 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1919 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1918 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1917 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1916 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1915 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1914 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1913 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1912 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1911 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x1910 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x199 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x198 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x197 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x196 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x195 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x194 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x193 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x192 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
x191 net33 sub GND vdd phi27 phi17 phi1_n7 phi2_n7 comp_m cap_switch_block
Vdd2 sub GND 0
x2010 net32 supply sub sphi2 vref sphi2_n tg
x209 net32 supply sub sphi2 vref sphi2_n tg
x208 net32 supply sub sphi2 vref sphi2_n tg
x207 net32 supply sub sphi2 vref sphi2_n tg
x206 net32 supply sub sphi2 vref sphi2_n tg
x205 net32 supply sub sphi2 vref sphi2_n tg
x204 net32 supply sub sphi2 vref sphi2_n tg
x203 net32 supply sub sphi2 vref sphi2_n tg
x202 net32 supply sub sphi2 vref sphi2_n tg
x201 net32 supply sub sphi2 vref sphi2_n tg
x2110 net32 supply sub sphi1 vinp sphi1_n tg
x219 net32 supply sub sphi1 vinp sphi1_n tg
x218 net32 supply sub sphi1 vinp sphi1_n tg
x217 net32 supply sub sphi1 vinp sphi1_n tg
x216 net32 supply sub sphi1 vinp sphi1_n tg
x215 net32 supply sub sphi1 vinp sphi1_n tg
x214 net32 supply sub sphi1 vinp sphi1_n tg
x213 net32 supply sub sphi1 vinp sphi1_n tg
x212 net32 supply sub sphi1 vinp sphi1_n tg
x211 net32 supply sub sphi1 vinp sphi1_n tg
x2210 comp_p vdd sub sample vcm sample_n tg
x229 comp_p vdd sub sample vcm sample_n tg
x228 comp_p vdd sub sample vcm sample_n tg
x227 comp_p vdd sub sample vcm sample_n tg
x226 comp_p vdd sub sample vcm sample_n tg
x225 comp_p vdd sub sample vcm sample_n tg
x224 comp_p vdd sub sample vcm sample_n tg
x223 comp_p vdd sub sample vcm sample_n tg
x222 comp_p vdd sub sample vcm sample_n tg
x221 comp_p vdd sub sample vcm sample_n tg
x2310 comp_m vdd sub sample vcm sample_n tg
x239 comp_m vdd sub sample vcm sample_n tg
x238 comp_m vdd sub sample vcm sample_n tg
x237 comp_m vdd sub sample vcm sample_n tg
x236 comp_m vdd sub sample vcm sample_n tg
x235 comp_m vdd sub sample vcm sample_n tg
x234 comp_m vdd sub sample vcm sample_n tg
x233 comp_m vdd sub sample vcm sample_n tg
x232 comp_m vdd sub sample vcm sample_n tg
x231 comp_m vdd sub sample vcm sample_n tg
x2410 net33 vdd sub sphi1 vinm sphi1_n tg
x249 net33 vdd sub sphi1 vinm sphi1_n tg
x248 net33 vdd sub sphi1 vinm sphi1_n tg
x247 net33 vdd sub sphi1 vinm sphi1_n tg
x246 net33 vdd sub sphi1 vinm sphi1_n tg
x245 net33 vdd sub sphi1 vinm sphi1_n tg
x244 net33 vdd sub sphi1 vinm sphi1_n tg
x243 net33 vdd sub sphi1 vinm sphi1_n tg
x242 net33 vdd sub sphi1 vinm sphi1_n tg
x241 net33 vdd sub sphi1 vinm sphi1_n tg
x2510 net33 vdd sub sphi2 vref sphi2_n tg
x259 net33 vdd sub sphi2 vref sphi2_n tg
x258 net33 vdd sub sphi2 vref sphi2_n tg
x257 net33 vdd sub sphi2 vref sphi2_n tg
x256 net33 vdd sub sphi2 vref sphi2_n tg
x255 net33 vdd sub sphi2 vref sphi2_n tg
x254 net33 vdd sub sphi2 vref sphi2_n tg
x253 net33 vdd sub sphi2 vref sphi2_n tg
x252 net33 vdd sub sphi2 vref sphi2_n tg
x251 net33 vdd sub sphi2 vref sphi2_n tg
**** begin user architecture code


.tran 10n 10u
.save all
.param vcc = 1.8
.param vdd = 1.8
.param vdiff = 200m
vvcc vcc 0 dc vcc
vvdd vdd 0 dc vdd
vvss vss 0 0
.control

run
plot comp_p comp_m
plot d0+2 d1+4 d2+6 d3+8 d4+10 d5+12 d6+14 d7+16 data_rdy+18
plot x2.net21 x2.net2+2 x2.net10+4 x2.net19+6
write sar_tb1.raw comp_p comp_m
set wr_singlescale
set wr_vecnames
wrdata sar1.txt comp_p comp_m d0 d1 d2 d3 d4 d5 d6 d7 data_rdy vinp vinm
.endc



.model SWITCH1 sw vt=0.9 vh=0 ron=1 roff =100G

**** end user architecture code
**.ends
.GLOBAL GND
.end
