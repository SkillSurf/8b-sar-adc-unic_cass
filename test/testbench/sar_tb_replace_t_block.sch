v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 350 310 350 470 {
lab=#net1}
N 350 270 350 310 {
lab=#net1}
N 450 -260 510 -260 {
lab=GND}
N 350 190 660 190 {
lab=comp_m}
N 350 190 350 210 {
lab=comp_m}
N 450 440 510 440 {
lab=GND}
N -3580 0 -3180 0 {
lab=comp_p}
N -3620 -290 -3280 -290 {
lab=#net2}
N -3650 -390 -3620 -390 {
lab=#net2}
N -3620 -390 -3620 -290 {
lab=#net2}
N -3650 570 -3620 570 {
lab=#net1}
N -3620 470 -3620 570 {
lab=#net1}
N -3620 470 -3280 470 {
lab=#net1}
N -3650 370 -3620 370 {
lab=#net1}
N -3620 370 -3620 470 {
lab=#net1}
N -3580 190 -3180 190 {
lab=comp_m}
N 660 0 660 70 {
lab=comp_p}
N 660 110 660 190 {
lab=comp_m}
N -3780 370 -3710 370 {
lab=vinm}
N -3620 -290 -3620 -190 {
lab=#net2}
N 350 -0 660 0 {
lab=comp_p}
N -3650 -190 -3620 -190 {
lab=#net2}
N -3760 -190 -3710 -190 {
lab=vinp}
N -3280 -290 -2830 -290 {
lab=#net2}
N -2830 -290 -2380 -290 {
lab=#net2}
N -2380 -290 -1930 -290 {
lab=#net2}
N -1930 -290 -1510 -290 {
lab=#net2}
N -1510 -290 -1070 -290 {
lab=#net2}
N -1070 -290 -620 -290 {
lab=#net2}
N -620 -290 -200 -290 {
lab=#net2}
N -2830 470 -2380 470 {
lab=#net1}
N -2380 470 -1930 470 {
lab=#net1}
N -1930 470 -1510 470 {
lab=#net1}
N -1510 470 -1070 470 {
lab=#net1}
N -1070 470 -620 470 {
lab=#net1}
N -620 470 -200 470 {
lab=#net1}
N -200 470 250 470 {
lab=#net1}
N -3180 -0 -2730 -0 {
lab=comp_p}
N -3280 470 -2830 470 {
lab=#net1}
N 660 70 770 70 {
lab=comp_p}
N 660 110 770 110 {
lab=comp_m}
N -200 -290 250 -290 {
lab=#net2}
N 890 90 910 90 {
lab=#net3}
N -1040 870 -1040 880 {
lab=GND}
N -1100 750 -1100 770 {
lab=vcm}
N -1040 770 -980 770 {
lab=vcm}
N -980 750 -980 770 {
lab=vcm}
N -1040 770 -1040 810 {
lab=vcm}
N -100 0 350 -0 {
lab=comp_p}
N -520 0 -100 0 {
lab=comp_p}
N -970 -0 -520 0 {
lab=comp_p}
N -1410 -0 -970 -0 {
lab=comp_p}
N -1830 0 -1410 -0 {
lab=comp_p}
N -2280 -0 -1830 0 {
lab=comp_p}
N -2730 0 -2280 -0 {
lab=comp_p}
N -2630 -260 -2180 -260 {
lab=GND}
N -2180 -260 -1730 -260 {
lab=GND}
N -1730 -260 -1310 -260 {
lab=GND}
N -1310 -260 -870 -260 {
lab=GND}
N -870 -260 -420 -260 {
lab=GND}
N -420 -260 0 -260 {
lab=GND}
N 0 -260 450 -260 {
lab=GND}
N -100 190 350 190 {
lab=comp_m}
N -520 190 -100 190 {
lab=comp_m}
N -970 190 -520 190 {
lab=comp_m}
N -1410 190 -970 190 {
lab=comp_m}
N -1830 190 -1410 190 {
lab=comp_m}
N -2280 190 -1830 190 {
lab=comp_m}
N -2730 190 -2280 190 {
lab=comp_m}
N -3180 190 -2730 190 {
lab=comp_m}
N -0 440 450 440 {
lab=GND}
N -420 440 -0 440 {
lab=GND}
N -870 440 -420 440 {
lab=GND}
N -1310 440 -870 440 {
lab=GND}
N -1730 440 -1310 440 {
lab=GND}
N -2180 440 -1730 440 {
lab=GND}
N -2630 440 -2180 440 {
lab=GND}
N -3080 440 -2630 440 {
lab=GND}
N -1100 770 -1040 770 {
lab=vcm}
N 250 470 350 470 {
lab=#net1}
N -3100 -1160 -3100 -1140 {
lab=data[7..0]}
N -3100 -1060 -3100 -1020 {
lab=#net4}
N -3100 -960 -2940 -960 {
lab=#net4}
N -3100 -1020 -3100 -960 {
lab=#net4}
N -2820 -1140 -2780 -1140 {
lab=#net5}
N -2700 -1140 -2660 -1140 {
lab=#net6}
N -2580 -1140 -2550 -1140 {
lab=#net7}
N -2820 -980 -2780 -980 {
lab=#net8}
N -2700 -980 -2660 -980 {
lab=#net9}
N -2580 -980 -2550 -980 {
lab=#net10}
N -2470 -980 -2430 -980 {
lab=d[7..0]}
N -2470 -1140 -2430 -1140 {
lab=dn[7..0]}
N -2460 -1140 -2460 -1110 {
lab=dn[7..0]}
N -2970 -1020 -2460 -1110 {
lab=dn[7..0]}
N -2970 -1020 -2970 -1000 {
lab=dn[7..0]}
N -2970 -1000 -2940 -1000 {
lab=dn[7..0]}
N -2460 -1010 -2460 -980 {
lab=d[7..0]}
N -2970 -1100 -2460 -1010 {
lab=d[7..0]}
N -2970 -1120 -2970 -1100 {
lab=d[7..0]}
N -2970 -1120 -2940 -1120 {
lab=d[7..0]}
N -2430 -1140 -2400 -1140 {
lab=dn[7..0]}
N -2430 -980 -2400 -980 {
lab=d[7..0]}
N -3100 -1160 -2950 -1160 {
lab=data[7..0]}
N -3130 -1160 -3100 -1160 {
lab=data[7..0]}
N -2950 -1160 -2940 -1160 {
lab=data[7..0]}
N -3560 -760 -3550 -760 {
lab=#net11}
N -3470 -760 -3460 -760 {
lab=#net12}
N -3380 -760 -3370 -760 {
lab=#net13}
N -3290 -760 -3280 -760 {
lab=#net14}
N -3110 -760 -3090 -760 {
lab=#net15}
N -3200 -760 -3190 -760 {
lab=#net16}
N -2240 -780 -2230 -780 {
lab=phi1[7..0]}
N -2410 -980 -2410 -800 {
lab=d[7..0]}
N -2410 -800 -2360 -800 {
lab=d[7..0]}
N -2420 -1250 -2420 -1140 {
lab=dn[7..0]}
N -2420 -1250 -2360 -1250 {
lab=dn[7..0]}
N -3090 -760 -3080 -760 {
lab=#net15}
N -3000 -760 -2990 -760 {
lab=#net17}
N -2910 -760 -2900 -760 {
lab=#net18}
N -2820 -760 -2810 -760 {
lab=#net19}
N -2640 -760 -2620 -760 {
lab=#net20}
N -2730 -760 -2720 -760 {
lab=#net21}
N -2620 -760 -2610 -760 {
lab=#net20}
N -2530 -760 -2520 -760 {
lab=#net22}
N -2440 -760 -2360 -760 {
lab=#net23}
N -2310 -680 -2300 -680 {
lab=#net24}
N -2220 -680 -2210 -680 {
lab=#net25}
N -2040 -680 -2020 -680 {
lab=#net26}
N -2130 -680 -2120 -680 {
lab=#net27}
N -2020 -680 -2010 -680 {
lab=#net26}
N -1930 -680 -1920 -680 {
lab=#net28}
N -2410 -680 -2390 -680 {
lab=#net23}
N -2410 -760 -2410 -680 {
lab=#net23}
N -1840 -680 -1770 -680 {
lab=#net29}
N 250 -290 250 -220 {
lab=#net2}
N 310 -260 310 -220 {
lab=GND}
N 280 -70 280 0 {
lab=comp_p}
N -110 -290 -110 -230 {
lab=#net2}
N -50 -260 -50 -230 {
lab=GND}
N -80 -80 -80 0 {
lab=comp_p}
N -480 -290 -480 -230 {
lab=#net2}
N -420 -260 -420 -230 {
lab=GND}
N -450 -80 -450 0 {
lab=comp_p}
N -840 -290 -840 -230 {
lab=#net2}
N -780 -260 -780 -230 {
lab=GND}
N -810 -80 -810 0 {
lab=comp_p}
N -1220 -290 -1220 -230 {
lab=#net2}
N -1160 -260 -1160 -230 {
lab=GND}
N -1190 -80 -1190 0 {
lab=comp_p}
N -1640 -290 -1640 -230 {
lab=#net2}
N -1580 -260 -1580 -230 {
lab=GND}
N -1610 -80 -1610 0 {
lab=comp_p}
N -2070 -290 -2070 -230 {
lab=#net2}
N -2010 -260 -2010 -230 {
lab=GND}
N -2040 -80 -2040 0 {
lab=comp_p}
N -2550 -290 -2550 -230 {
lab=#net2}
N -2490 -260 -2490 -230 {
lab=GND}
N -2520 -80 -2520 0 {
lab=comp_p}
N -3050 -290 -3050 -230 {
lab=#net2}
N -2990 -260 -2990 -230 {
lab=GND}
N -3020 -80 -3020 0 {
lab=comp_p}
N -2990 -260 -2630 -260 {
lab=GND}
N -3170 190 -3170 270 {
lab=comp_m}
N -3140 420 -3140 470 {
lab=#net1}
N -3200 440 -3080 440 {
lab=GND}
N -3200 420 -3200 440 {
lab=GND}
N -2730 190 -2730 270 {
lab=comp_m}
N -2760 420 -2760 440 {
lab=GND}
N -2700 420 -2700 470 {
lab=#net1}
N -2320 190 -2320 270 {
lab=comp_m}
N -2350 420 -2350 440 {
lab=GND}
N -2290 420 -2290 470 {
lab=#net1}
N -1860 190 -1860 270 {
lab=comp_m}
N -1890 420 -1890 440 {
lab=GND}
N -1830 420 -1830 470 {
lab=#net1}
N -1420 190 -1420 270 {
lab=comp_m}
N -1450 420 -1450 440 {
lab=GND}
N -1390 420 -1390 470 {
lab=#net1}
N -1000 190 -1000 270 {
lab=comp_m}
N -1030 420 -1030 440 {
lab=GND}
N -970 420 -970 470 {
lab=#net1}
N -540 190 -540 270 {
lab=comp_m}
N -570 420 -570 440 {
lab=GND}
N -510 420 -510 470 {
lab=#net1}
N -100 190 -100 270 {
lab=comp_m}
N -130 420 -130 440 {
lab=GND}
N -70 420 -70 470 {
lab=#net1}
N -2240 -1270 -2190 -1270 {
lab=phi2[7..0]}
C {lab_pin.sym} 190 -170 0 0 {name=p35 sig_type=std_logic lab=smpl}
C {lab_pin.sym} 190 -130 0 0 {name=p36 sig_type=std_logic lab=smpl_n_d12}
C {sky130_fd_pr/cap_mim_m3_1.sym} 350 240 0 1 {name=C18 model=cap_mim_m3_1 W=7 L=7 MF=1 spiceprefix=X}
C {switch_ngspice.sym} -3680 -390 1 0 {name=S37 model=SWITCH1}
C {lab_pin.sym} -3680 -430 1 0 {name=p76 sig_type=std_logic lab=smpl_n_d12}
C {switch_ngspice.sym} -3680 370 1 0 {name=S39 model=SWITCH1}
C {switch_ngspice.sym} -3680 570 1 0 {name=S40 model=SWITCH1}
C {lab_pin.sym} -3680 530 1 0 {name=p79 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} -3680 330 1 0 {name=p80 sig_type=std_logic lab=smpl}
C {switch_ngspice.sym} -3610 0 1 0 {name=S41 model=SWITCH1}
C {lab_pin.sym} -3610 -40 1 0 {name=p82 sig_type=std_logic lab=smpl}
C {switch_ngspice.sym} -3610 190 1 0 {name=S42 model=SWITCH1}
C {lab_pin.sym} -3610 150 1 0 {name=p84 sig_type=std_logic lab=smpl
}
C {lab_pin.sym} -3640 0 0 0 {name=p85 sig_type=std_logic lab=vcm}
C {lab_pin.sym} -3640 190 0 0 {name=p86 sig_type=std_logic lab=vcm}
C {lab_pin.sym} -3710 -390 0 0 {name=p87 sig_type=std_logic lab=vref}
C {lab_pin.sym} -3710 570 0 0 {name=p88 sig_type=std_logic lab=vref}
C {lab_pin.sym} -3760 -190 0 0 {name=p90 sig_type=std_logic lab=vinp}
C {vsource.sym} -110 780 0 0 {name=Vdd8 value="pulse(1.8 0 1n 1n 1n 50n 100u 1)" savecurrent=false}
C {gnd.sym} -110 810 0 0 {name=l6 lab=GND}
C {vsource.sym} -320 780 0 0 {name=Vdd4 value="pulse(0 1.8 1n 1n 1n 500n 1u)" savecurrent=false}
C {gnd.sym} -320 810 0 0 {name=l7 lab=GND}
C {lab_pin.sym} -320 750 1 0 {name=p98 sig_type=std_logic lab=clk}
C {lab_pin.sym} -110 750 1 0 {name=p99 sig_type=std_logic lab=rst_n}
C {devices/code.sym} -3210 -1500 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/code_shown.sym} -3050 -1660 0 0 {name=STIMULI
only_toplevel=true
value="
.tran 10n 20u
.save all
.param vcc = 1.8
.param vdd = 1.8
.param vdiff = 500m
vvcc vcc 0 dc vcc
vvdd vdd 0 dc vdd
vvss vss 0 0
.control

run
plot comp_p comp_m
plot d0+2 d1+4 d2+6 d3+8 d4+10 d5+12 d6+14 d7+16 data_rdy+18
write sar_tb.raw comp_p comp_m
set wr_singlescale
set wr_vecnames
wrdata sar.txt comp_p comp_m
.endc
"}
C {code.sym} -3350 -1500 0 0 {name=SWITCH1 only_toplevel=false value=".model SWITCH1 sw vt=0.9 vh=0 ron=1 roff =100G"}
C {gnd.sym} 510 -260 0 0 {name=l2 lab=GND}
C {lab_pin.sym} -3130 -1160 0 0 {name=p104 sig_type=std_logic lab=data[7..0]}
C {vsource.sym} -560 780 0 0 {name=Vdd1 value=1.8 savecurrent=false}
C {gnd.sym} -560 810 0 0 {name=l3 lab=GND}
C {lab_pin.sym} -560 750 1 0 {name=p107 sig_type=std_logic lab=vref}
C {lab_pin.sym} 660 0 0 1 {name=p111 sig_type=std_logic lab=comp_p}
C {lab_pin.sym} 660 190 0 1 {name=p112 sig_type=std_logic lab=comp_m}
C {lab_pin.sym} -3680 -230 3 1 {name=p135 sig_type=std_logic lab=smpl}
C {switch_ngspice.sym} -3680 -190 1 0 {name=S38 model=SWITCH1}
C {lab_pin.sym} -2430 -980 3 0 {name=p136 sig_type=std_logic lab=d[7..0]}
C {sky130_stdcells/inv_8.sym} 950 90 0 0 {name=x3 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} 990 90 2 0 {name=p110 sig_type=std_logic lab=comp_out}
C {gnd.sym} 510 440 0 0 {name=l1 lab=GND}
C {lab_pin.sym} -3780 370 0 0 {name=p89 sig_type=std_logic lab=vinm}
C {gnd.sym} -3700 -430 2 0 {name=l56 lab=GND
value=0.6}
C {gnd.sym} -3700 -230 2 0 {name=l57 lab=GND
value=0.6}
C {gnd.sym} -3630 -40 2 0 {name=l58 lab=GND
value=0.6}
C {gnd.sym} -3630 150 2 0 {name=l59 lab=GND
value=0.6}
C {gnd.sym} -3700 330 2 0 {name=l60 lab=GND
value=0.6}
C {gnd.sym} -3700 530 2 0 {name=l61 lab=GND
value=0.6}
C {lab_pin.sym} -4030 -1070 0 0 {name=p1 sig_type=std_logic lab=clk}
C {lab_pin.sym} -4030 -1050 0 0 {name=p4 sig_type=std_logic lab=rst_n}
C {lab_pin.sym} -4030 -1030 0 0 {name=p5 sig_type=std_logic lab=comp_out}
C {lab_pin.sym} -3730 -1070 2 0 {name=p6 sig_type=std_logic lab=data_rdy}
C {lab_pin.sym} -3730 -1050 2 0 {name=p9 sig_type=std_logic lab=smpl}
C {lab_pin.sym} -3730 -1030 2 0 {name=p10 sig_type=std_logic lab=smpl_n}
C {lab_pin.sym} -3730 -990 2 0 {name=p13 sig_type=std_logic lab=supply}
C {lab_pin.sym} -3730 -970 2 0 {name=p14 sig_type=std_logic lab=data[7..0]}
C {lab_pin.sym} -3730 -950 2 0 {name=p17 sig_type=std_logic lab=data_n[7..0]}
C {gnd.sym} -3730 -1010 3 0 {name=l18 lab=GND}
C {vsource.sym} -650 780 0 0 {name=Vdd5 value=1.8 savecurrent=false}
C {gnd.sym} -650 810 0 0 {name=l19 lab=GND}
C {lab_pin.sym} -650 750 1 0 {name=p18 sig_type=std_logic lab=supply}
C {devices/vsource.sym} -1040 840 0 0 {name=V_VCM_2 value=0.9}
C {devices/gnd.sym} -1040 880 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -1040 800 0 0 {name=l11 sig_type=std_logic lab=vcm}
C {devices/vsource.sym} -1100 720 0 0 {name=V_VCM_1 value=\{vdiff/2\}}
C {devices/vsource.sym} -980 720 2 1 {name=V_VCM_3 value=\{vdiff/2\}}
C {lab_pin.sym} -980 690 1 0 {name=p21 sig_type=std_logic lab=vinm}
C {lab_pin.sym} -1100 690 1 0 {name=p22 sig_type=std_logic lab=vinp}
C {sky130_stdcells/inv_2.sym} -3100 -1100 1 0 {name=x21[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/nor2_1.sym} -2880 -1140 0 0 {name=x22[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/nor2_1.sym} -2880 -980 0 0 {name=x23[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2740 -1140 0 0 {name=x24[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2620 -1140 0 0 {name=x25[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2510 -1140 0 0 {name=x26[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2740 -980 0 0 {name=x27[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2620 -980 0 0 {name=x28[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2510 -980 0 0 {name=x29[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -2360 -1140 0 0 {name=x30[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -2360 -980 0 0 {name=x31[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2320 -980 2 0 {name=p45 sig_type=std_logic lab=d_n[7..0]}
C {lab_pin.sym} -2430 -1140 3 0 {name=p42 sig_type=std_logic lab=dn[7..0]}
C {lab_pin.sym} -2320 -1140 2 0 {name=p49 sig_type=std_logic lab=dn_n[7..0]}
C {sky130_stdcells/or2_1.sym} -2300 -780 0 0 {name=x1[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -3640 -760 0 0 {name=p30 sig_type=std_logic lab=smpl}
C {sky130_stdcells/buf_1.sym} -3600 -760 0 0 {name=x21 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3510 -760 0 0 {name=x22 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3420 -760 0 0 {name=x23 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3330 -760 0 0 {name=x24 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3240 -760 0 0 {name=x25 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3150 -760 0 0 {name=x26 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2240 -780 1 0 {name=p37 sig_type=std_logic lab=phi1[7..0]}
C {sky130_stdcells/inv_2.sym} -2190 -780 0 0 {name=x2[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2150 -780 2 0 {name=p38 sig_type=std_logic lab=phi1_n[7..0]}
C {sky130_stdcells/and2_2.sym} -2300 -1270 0 0 {name=x12[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2360 -1290 0 0 {name=p26 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} -2240 -1270 3 0 {name=p41 sig_type=std_logic lab=phi2[7..0]}
C {sky130_stdcells/buf_1.sym} -3040 -760 0 0 {name=x4 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2950 -760 0 0 {name=x5 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2860 -760 0 0 {name=x6 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2770 -760 0 0 {name=x18 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_2.sym} -2680 -760 0 0 {name=x19 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_4.sym} -2570 -760 0 0 {name=x20 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_6.sym} -2480 -760 0 0 {name=x27 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_8.sym} -1730 -680 0 0 {name=x28 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -1690 -680 2 0 {name=p33 sig_type=std_logic lab=smpl_n_d12}
C {sky130_stdcells/buf_1.sym} -2350 -680 0 0 {name=x29 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2260 -680 0 0 {name=x30 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2170 -680 0 0 {name=x31 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_2.sym} -2080 -680 0 0 {name=x32 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_4.sym} -1970 -680 0 0 {name=x33 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_6.sym} -1880 -680 0 0 {name=x34 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {cap_switch_block.sym} 280 -140 0 0 {name=x7}
C {lab_pin.sym} -170 -180 0 0 {name=p2 sig_type=std_logic lab=phi10}
C {lab_pin.sym} -170 -160 0 0 {name=p3 sig_type=std_logic lab=phi1_n0}
C {cap_switch_block.sym} -80 -150 0 0 {name=x8}
C {lab_pin.sym} 370 -150 2 0 {name=p25 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 10 -160 2 0 {name=p29 sig_type=std_logic lab=vdd}
C {sky130_stdcells/inv_2.sym} -2150 -1270 0 0 {name=x3[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2110 -1270 2 0 {name=p50 sig_type=std_logic lab=phi2_n[7..0]}
C {lab_pin.sym} -170 -140 0 0 {name=p34 sig_type=std_logic lab=phi20}
C {lab_pin.sym} -170 -120 0 0 {name=p46 sig_type=std_logic lab=phi2_n0}
C {lab_pin.sym} -540 -180 0 0 {name=p7 sig_type=std_logic lab=phi11}
C {lab_pin.sym} -540 -160 0 0 {name=p8 sig_type=std_logic lab=phi1_n1}
C {cap_switch_block.sym} -450 -150 0 0 {name=x9[1:0]}
C {lab_pin.sym} -360 -160 2 0 {name=p53 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -540 -140 0 0 {name=p54 sig_type=std_logic lab=phi21}
C {lab_pin.sym} -540 -120 0 0 {name=p57 sig_type=std_logic lab=phi2_n1}
C {lab_pin.sym} -900 -180 0 0 {name=p11 sig_type=std_logic lab=phi12}
C {lab_pin.sym} -900 -160 0 0 {name=p12 sig_type=std_logic lab=phi1_n2}
C {cap_switch_block.sym} -810 -150 0 0 {name=x4[3:0]}
C {lab_pin.sym} -720 -160 2 0 {name=p58 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -900 -140 0 0 {name=p61 sig_type=std_logic lab=phi22}
C {lab_pin.sym} -900 -120 0 0 {name=p62 sig_type=std_logic lab=phi2_n2}
C {lab_pin.sym} -1280 -180 0 0 {name=p15 sig_type=std_logic lab=phi13}
C {lab_pin.sym} -1280 -160 0 0 {name=p16 sig_type=std_logic lab=phi1_n3}
C {cap_switch_block.sym} -1190 -150 0 0 {name=x5[7:0]}
C {lab_pin.sym} -1100 -160 2 0 {name=p65 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -1280 -140 0 0 {name=p66 sig_type=std_logic lab=phi23}
C {lab_pin.sym} -1280 -120 0 0 {name=p69 sig_type=std_logic lab=phi2_n3}
C {lab_pin.sym} -1700 -180 0 0 {name=p19 sig_type=std_logic lab=phi14}
C {lab_pin.sym} -1700 -160 0 0 {name=p20 sig_type=std_logic lab=phi1_n4}
C {cap_switch_block.sym} -1610 -150 0 0 {name=x6[15:0]}
C {lab_pin.sym} -1520 -160 2 0 {name=p70 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -1700 -140 0 0 {name=p71 sig_type=std_logic lab=phi24}
C {lab_pin.sym} -1700 -120 0 0 {name=p72 sig_type=std_logic lab=phi2_n4}
C {lab_pin.sym} -2130 -180 0 0 {name=p23 sig_type=std_logic lab=phi15}
C {lab_pin.sym} -2130 -160 0 0 {name=p24 sig_type=std_logic lab=phi1_n5}
C {cap_switch_block.sym} -2040 -150 0 0 {name=x7[31:0]}
C {lab_pin.sym} -1950 -160 2 0 {name=p73 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -2130 -140 0 0 {name=p74 sig_type=std_logic lab=phi25}
C {lab_pin.sym} -2130 -120 0 0 {name=p75 sig_type=std_logic lab=phi2_n5}
C {lab_pin.sym} -2610 -180 0 0 {name=p27 sig_type=std_logic lab=phi16}
C {lab_pin.sym} -2610 -160 0 0 {name=p28 sig_type=std_logic lab=phi1_n6}
C {cap_switch_block.sym} -2520 -150 0 0 {name=x8[63:0]}
C {lab_pin.sym} -2430 -160 2 0 {name=p77 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -2610 -140 0 0 {name=p78 sig_type=std_logic lab=phi26}
C {lab_pin.sym} -2610 -120 0 0 {name=p81 sig_type=std_logic lab=phi2_n6}
C {lab_pin.sym} -3110 -180 0 0 {name=p31 sig_type=std_logic lab=phi17}
C {lab_pin.sym} -3110 -160 0 0 {name=p32 sig_type=std_logic lab=phi1_n7}
C {cap_switch_block.sym} -3020 -150 0 0 {name=x10[128:0]}
C {lab_pin.sym} -2930 -160 2 0 {name=p83 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -3110 -140 0 0 {name=p91 sig_type=std_logic lab=phi27}
C {lab_pin.sym} -3110 -120 0 0 {name=p92 sig_type=std_logic lab=phi2_n7}
C {cap_switch_block.sym} -3170 340 2 0 {name=x11[128:0]}
C {lab_pin.sym} -3260 350 0 0 {name=p95 sig_type=std_logic lab=vdd}
C {cap_switch_block.sym} -2730 340 2 0 {name=x13[63:0]}
C {lab_pin.sym} -2820 350 0 0 {name=p43 sig_type=std_logic lab=vdd}
C {cap_switch_block.sym} -2320 340 2 0 {name=x14[31:0]}
C {lab_pin.sym} -2410 350 0 0 {name=p101 sig_type=std_logic lab=vdd}
C {cap_switch_block.sym} -1860 340 2 0 {name=x15[15:0]}
C {lab_pin.sym} -1950 350 0 0 {name=p105 sig_type=std_logic lab=vdd}
C {cap_switch_block.sym} -1420 340 2 0 {name=x16[7:0]}
C {lab_pin.sym} -1510 350 0 0 {name=p56 sig_type=std_logic lab=vdd}
C {cap_switch_block.sym} -1000 340 2 0 {name=x17[3:0]}
C {lab_pin.sym} -1090 350 0 0 {name=p114 sig_type=std_logic lab=vdd}
C {cap_switch_block.sym} -540 340 2 0 {name=x18[1:0]}
C {lab_pin.sym} -630 350 0 0 {name=p117 sig_type=std_logic lab=vdd}
C {cap_switch_block.sym} -100 340 2 0 {name=x9}
C {lab_pin.sym} -190 350 0 0 {name=p120 sig_type=std_logic lab=vdd}
C {sar_controller.sym} -3880 -1010 0 0 {name=x2}
C {gnd.sym} 370 -130 0 0 {name=l8 lab=GND}
C {gnd.sym} 10 -140 0 0 {name=l9 lab=GND}
C {gnd.sym} -360 -140 0 0 {name=l12 lab=GND}
C {gnd.sym} -720 -140 0 0 {name=l13 lab=GND}
C {gnd.sym} -1100 -140 0 0 {name=l14 lab=GND}
C {gnd.sym} -1520 -140 0 0 {name=l15 lab=GND}
C {gnd.sym} -1950 -140 0 0 {name=l16 lab=GND}
C {gnd.sym} -2430 -140 0 0 {name=l17 lab=GND}
C {gnd.sym} -2930 -140 0 0 {name=l20 lab=GND}
C {gnd.sym} -3260 330 0 0 {name=l21 lab=GND}
C {gnd.sym} -2820 330 0 0 {name=l22 lab=GND}
C {gnd.sym} -2410 330 0 0 {name=l23 lab=GND}
C {gnd.sym} -1950 330 0 0 {name=l24 lab=GND}
C {gnd.sym} -1510 330 0 0 {name=l25 lab=GND}
C {gnd.sym} -1090 330 0 0 {name=l26 lab=GND}
C {gnd.sym} -630 330 0 0 {name=l27 lab=GND}
C {gnd.sym} -190 330 0 0 {name=l28 lab=GND}
C {comp_behavioral.sym} 810 90 0 0 {name=x1 OFFSET=0.9 AMPLITUDE=0.9 GAIN=100000 ROUT=00 COUT=0}
C {inv_vtc.sym} 280 -610 0 0 {name=x10}
C {lab_pin.sym} 240 -860 1 0 {name=p124 sig_type=std_logic lab=vdd}
C {gnd.sym} 240 -730 0 0 {name=l4 lab=GND}
C {lab_pin.sym} 150 -800 0 0 {name=p125 sig_type=std_logic lab=smpl}
C {lab_pin.sym} 330 -800 2 0 {name=p126 sig_type=std_logic lab=smpl_out_n}
C {lab_pin.sym} 190 -150 0 0 {name=p127 sig_type=std_logic lab=smpl_out_n}
C {inv_vtc.sym} 280 -400 0 0 {name=x11}
C {lab_pin.sym} 240 -650 1 0 {name=p128 sig_type=std_logic lab=vdd}
C {gnd.sym} 240 -520 0 0 {name=l5 lab=GND}
C {lab_pin.sym} 150 -590 0 0 {name=p129 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} 330 -590 2 0 {name=p130 sig_type=std_logic lab=smpl_n_d12_out_n}
C {lab_pin.sym} 190 -110 0 0 {name=p131 sig_type=std_logic lab=smpl_n_d12_out_n}
C {lab_pin.sym} -10 370 0 1 {name=p132 sig_type=std_logic lab=dn0}
C {lab_pin.sym} -10 330 0 1 {name=p133 sig_type=std_logic lab=d0}
C {lab_pin.sym} -450 370 0 1 {name=p63 sig_type=std_logic lab=dn1}
C {lab_pin.sym} -450 330 0 1 {name=p64 sig_type=std_logic lab=d1}
C {lab_pin.sym} -910 370 0 1 {name=p59 sig_type=std_logic lab=dn2}
C {lab_pin.sym} -910 330 0 1 {name=p60 sig_type=std_logic lab=d2}
C {lab_pin.sym} -1330 370 0 1 {name=p55 sig_type=std_logic lab=dn3}
C {lab_pin.sym} -1330 330 0 1 {name=p67 sig_type=std_logic lab=d3}
C {lab_pin.sym} -1770 370 0 1 {name=p51 sig_type=std_logic lab=dn4}
C {lab_pin.sym} -1770 330 0 1 {name=p52 sig_type=std_logic lab=d4}
C {lab_pin.sym} -2230 370 0 1 {name=p47 sig_type=std_logic lab=dn5}
C {lab_pin.sym} -2230 330 0 1 {name=p48 sig_type=std_logic lab=d5}
C {lab_pin.sym} -2640 370 0 1 {name=p39 sig_type=std_logic lab=dn6}
C {lab_pin.sym} -2640 330 0 1 {name=p40 sig_type=std_logic lab=d6}
C {lab_pin.sym} -3080 370 0 1 {name=p44 sig_type=std_logic lab=dn7}
C {lab_pin.sym} -3080 330 0 1 {name=p68 sig_type=std_logic lab=d7}
C {lab_pin.sym} -10 350 0 1 {name=p93 sig_type=std_logic lab=dn_n0}
C {lab_pin.sym} -10 310 0 1 {name=p94 sig_type=std_logic lab=d_n0}
C {lab_pin.sym} -450 350 0 1 {name=p96 sig_type=std_logic lab=dn_n1}
C {lab_pin.sym} -450 310 0 1 {name=p97 sig_type=std_logic lab=d_n1}
C {lab_pin.sym} -910 350 0 1 {name=p100 sig_type=std_logic lab=dn_n2}
C {lab_pin.sym} -910 310 0 1 {name=p102 sig_type=std_logic lab=d_n2}
C {lab_pin.sym} -1330 350 0 1 {name=p103 sig_type=std_logic lab=dn_n3}
C {lab_pin.sym} -1330 310 0 1 {name=p106 sig_type=std_logic lab=d_n3}
C {lab_pin.sym} -1770 350 0 1 {name=p108 sig_type=std_logic lab=dn_n4}
C {lab_pin.sym} -1770 310 0 1 {name=p109 sig_type=std_logic lab=d_n4}
C {lab_pin.sym} -2230 350 0 1 {name=p113 sig_type=std_logic lab=dn_n5}
C {lab_pin.sym} -2230 310 0 1 {name=p115 sig_type=std_logic lab=d_n5}
C {lab_pin.sym} -2640 350 0 1 {name=p116 sig_type=std_logic lab=dn_n6}
C {lab_pin.sym} -2640 310 0 1 {name=p118 sig_type=std_logic lab=d_n6}
C {lab_pin.sym} -3080 350 0 1 {name=p119 sig_type=std_logic lab=dn_n7}
C {lab_pin.sym} -3080 310 0 1 {name=p121 sig_type=std_logic lab=d_n7}
