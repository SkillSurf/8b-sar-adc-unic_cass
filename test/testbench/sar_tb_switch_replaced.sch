v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -100 -120 -100 -80 {
lab=#net1}
N -520 -120 -520 -80 {
lab=#net2}
N -970 -120 -970 -80 {
lab=#net3}
N -1410 -120 -1410 -80 {
lab=#net4}
N -1830 -120 -1830 -80 {
lab=#net5}
N -2280 -120 -2280 -80 {
lab=#net6}
N -2830 -120 -2730 -120 {
lab=#net7}
N -2730 -120 -2730 -80 {
lab=#net7}
N -2730 -120 -2630 -120 {
lab=#net7}
N 350 -120 350 -80 {
lab=#net8}
N -3180 270 -3180 310 {
lab=#net9}
N -2730 270 -2730 310 {
lab=#net10}
N -2280 270 -2280 310 {
lab=#net11}
N -1830 270 -1830 310 {
lab=#net12}
N -1410 270 -1410 310 {
lab=#net13}
N -970 270 -970 310 {
lab=#net14}
N -520 270 -520 310 {
lab=#net15}
N -100 270 -100 310 {
lab=#net16}
N 350 310 350 470 {
lab=#net17}
N 350 270 350 310 {
lab=#net17}
N -3180 -20 -3180 -0 {
lab=comp_p}
N 350 -20 350 -0 {
lab=comp_p}
N -100 -20 -100 0 {
lab=comp_p}
N -520 -20 -520 0 {
lab=comp_p}
N -970 -20 -970 -0 {
lab=comp_p}
N -1410 -20 -1410 -0 {
lab=comp_p}
N -1830 -20 -1830 0 {
lab=comp_p}
N -2280 -20 -2280 -0 {
lab=comp_p}
N -2730 -20 -2730 -0 {
lab=comp_p}
N -3180 190 -3180 210 {
lab=comp_m}
N 350 190 660 190 {
lab=comp_m}
N 350 190 350 210 {
lab=comp_m}
N -100 190 -100 210 {
lab=comp_m}
N -520 190 -520 210 {
lab=comp_m}
N -970 190 -970 210 {
lab=comp_m}
N -1410 190 -1410 210 {
lab=comp_m}
N -1830 190 -1830 210 {
lab=comp_m}
N -2280 190 -2280 210 {
lab=comp_m}
N -2730 190 -2730 210 {
lab=comp_m}
N -3580 0 -3180 0 {
lab=comp_p}
N -3620 -290 -3280 -290 {
lab=#net18}
N -3650 -390 -3620 -390 {
lab=#net18}
N -3620 -390 -3620 -290 {
lab=#net18}
N -3650 570 -3620 570 {
lab=#net17}
N -3620 470 -3620 570 {
lab=#net17}
N -3620 470 -3280 470 {
lab=#net17}
N -3650 370 -3620 370 {
lab=#net17}
N -3620 370 -3620 470 {
lab=#net17}
N -3580 190 -3180 190 {
lab=comp_m}
N 660 0 660 70 {
lab=comp_p}
N 660 110 660 190 {
lab=comp_m}
N -3620 -290 -3620 -190 {
lab=#net18}
N 350 -0 660 0 {
lab=comp_p}
N -3280 -120 -3180 -120 {
lab=#net19}
N -3180 -120 -3180 -80 {
lab=#net19}
N -3180 -120 -3080 -120 {
lab=#net19}
N -3280 -290 -2830 -290 {
lab=#net18}
N -2830 -290 -2380 -290 {
lab=#net18}
N -2380 -290 -1930 -290 {
lab=#net18}
N -1930 -290 -1510 -290 {
lab=#net18}
N -1510 -290 -1070 -290 {
lab=#net18}
N -1070 -290 -620 -290 {
lab=#net18}
N -620 -290 -200 -290 {
lab=#net18}
N -2830 470 -2380 470 {
lab=#net17}
N -2380 470 -1930 470 {
lab=#net17}
N -1930 470 -1510 470 {
lab=#net17}
N -1510 470 -1070 470 {
lab=#net17}
N -1070 470 -620 470 {
lab=#net17}
N -620 470 -200 470 {
lab=#net17}
N -200 470 250 470 {
lab=#net17}
N -3180 -0 -2730 -0 {
lab=comp_p}
N -3280 470 -2830 470 {
lab=#net17}
N 660 70 770 70 {
lab=comp_p}
N 660 110 770 110 {
lab=comp_m}
N -200 -290 250 -290 {
lab=#net18}
N 890 90 910 90 {
lab=#net20}
N -1040 870 -1040 880 {
lab=#net21}
N -1100 750 -1100 770 {
lab=#net22}
N -1040 770 -980 770 {
lab=#net22}
N -980 750 -980 770 {
lab=#net22}
N -1040 770 -1040 810 {
lab=#net22}
N -100 0 350 -0 {
lab=comp_p}
N -520 0 -100 0 {
lab=comp_p}
N -970 -0 -520 0 {
lab=comp_p}
N -1410 -0 -970 -0 {
lab=comp_p}
N -1830 0 -1410 -0 {
lab=comp_p}
N -2280 -0 -1830 0 {
lab=comp_p}
N -2730 0 -2280 -0 {
lab=comp_p}
N -100 190 350 190 {
lab=comp_m}
N -520 190 -100 190 {
lab=comp_m}
N -970 190 -520 190 {
lab=comp_m}
N -1410 190 -970 190 {
lab=comp_m}
N -1830 190 -1410 190 {
lab=comp_m}
N -2280 190 -1830 190 {
lab=comp_m}
N -2730 190 -2280 190 {
lab=comp_m}
N -3180 190 -2730 190 {
lab=comp_m}
N -1100 770 -1040 770 {
lab=#net22}
N 250 470 350 470 {
lab=#net17}
N -3100 -1160 -3100 -1140 {
lab=data[7..0]}
N -3100 -1060 -3100 -1020 {
lab=#net23}
N -3100 -960 -2940 -960 {
lab=#net23}
N -3100 -1020 -3100 -960 {
lab=#net23}
N -2820 -1140 -2780 -1140 {
lab=#net24}
N -2700 -1140 -2660 -1140 {
lab=#net25}
N -2580 -1140 -2550 -1140 {
lab=#net26}
N -2820 -980 -2780 -980 {
lab=#net27}
N -2700 -980 -2660 -980 {
lab=#net28}
N -2580 -980 -2550 -980 {
lab=#net29}
N -2470 -980 -2430 -980 {
lab=d[7..0]}
N -2470 -1140 -2430 -1140 {
lab=dn[7..0]}
N -2460 -1140 -2460 -1110 {
lab=dn[7..0]}
N -2970 -1020 -2460 -1110 {
lab=dn[7..0]}
N -2970 -1020 -2970 -1000 {
lab=dn[7..0]}
N -2970 -1000 -2940 -1000 {
lab=dn[7..0]}
N -2460 -1010 -2460 -980 {
lab=d[7..0]}
N -2970 -1100 -2460 -1010 {
lab=d[7..0]}
N -2970 -1120 -2970 -1100 {
lab=d[7..0]}
N -2970 -1120 -2940 -1120 {
lab=d[7..0]}
N -2430 -1140 -2400 -1140 {
lab=dn[7..0]}
N -2430 -980 -2400 -980 {
lab=d[7..0]}
N -3100 -1160 -2950 -1160 {
lab=data[7..0]}
N -3130 -1160 -3100 -1160 {
lab=data[7..0]}
N -2950 -1160 -2940 -1160 {
lab=data[7..0]}
N -3560 -760 -3550 -760 {
lab=#net30}
N -3470 -760 -3460 -760 {
lab=#net31}
N -3380 -760 -3370 -760 {
lab=#net32}
N -3290 -760 -3280 -760 {
lab=#net33}
N -3110 -760 -3090 -760 {
lab=#net34}
N -3200 -760 -3190 -760 {
lab=#net35}
N -2240 -780 -2230 -780 {
lab=dx[7..0]}
N -2410 -980 -2410 -800 {
lab=d[7..0]}
N -2410 -800 -2360 -800 {
lab=d[7..0]}
N -2420 -1250 -2420 -1140 {
lab=dn[7..0]}
N -2420 -1250 -2360 -1250 {
lab=dn[7..0]}
N -3090 -760 -3080 -760 {
lab=#net34}
N -3000 -760 -2990 -760 {
lab=#net36}
N -2910 -760 -2900 -760 {
lab=#net37}
N -2820 -760 -2810 -760 {
lab=#net38}
N -2640 -760 -2620 -760 {
lab=#net39}
N -2730 -760 -2720 -760 {
lab=#net40}
N -2620 -760 -2610 -760 {
lab=#net39}
N -2530 -760 -2520 -760 {
lab=#net41}
N -2440 -760 -2360 -760 {
lab=#net42}
N -2310 -680 -2300 -680 {
lab=#net43}
N -2220 -680 -2210 -680 {
lab=#net44}
N -2040 -680 -2020 -680 {
lab=#net45}
N -2130 -680 -2120 -680 {
lab=#net46}
N -2020 -680 -2010 -680 {
lab=#net45}
N -1930 -680 -1920 -680 {
lab=#net47}
N -2410 -680 -2390 -680 {
lab=#net42}
N -2410 -760 -2410 -680 {
lab=#net42}
N -1840 -680 -1770 -680 {
lab=#net48}
N -3680 -240 -3650 -240 {
lab=GND}
N -3280 -290 -3280 -260 {
lab=#net18}
N -3280 -140 -3280 -120 {
lab=#net19}
N -3080 -140 -3080 -120 {
lab=#net19}
N -2830 -290 -2830 -260 {
lab=#net18}
N -2830 -140 -2830 -120 {
lab=#net7}
N -3080 -270 -3080 -260 {
lab=GND}
N -2630 -270 -2630 -260 {
lab=GND}
N -2630 -140 -2630 -120 {
lab=#net7}
N -2380 -120 -2280 -120 {
lab=#net6}
N -2280 -120 -2180 -120 {
lab=#net6}
N -2380 -140 -2380 -120 {
lab=#net6}
N -2180 -270 -2180 -260 {
lab=GND}
N -2180 -140 -2180 -120 {
lab=#net6}
N -2380 -290 -2380 -260 {
lab=#net18}
N -1920 -120 -1820 -120 {
lab=#net5}
N -1820 -120 -1720 -120 {
lab=#net5}
N -1920 -140 -1920 -120 {
lab=#net5}
N -1720 -270 -1720 -260 {
lab=GND}
N -1720 -140 -1720 -120 {
lab=#net5}
N -1920 -290 -1920 -260 {
lab=#net18}
N -1500 -120 -1400 -120 {
lab=#net4}
N -1400 -120 -1300 -120 {
lab=#net4}
N -1500 -140 -1500 -120 {
lab=#net4}
N -1300 -270 -1300 -260 {
lab=GND}
N -1300 -140 -1300 -120 {
lab=#net4}
N -1070 -120 -970 -120 {
lab=#net3}
N -970 -120 -870 -120 {
lab=#net3}
N -1070 -140 -1070 -120 {
lab=#net3}
N -870 -270 -870 -260 {
lab=GND}
N -870 -140 -870 -120 {
lab=#net3}
N -1500 -290 -1500 -260 {
lab=#net18}
N -1070 -290 -1070 -260 {
lab=#net18}
N -610 -120 -510 -120 {
lab=#net2}
N -510 -120 -410 -120 {
lab=#net2}
N -610 -140 -610 -120 {
lab=#net2}
N -410 -270 -410 -260 {
lab=GND}
N -410 -140 -410 -120 {
lab=#net2}
N -210 -120 -110 -120 {
lab=#net1}
N -110 -120 -10 -120 {
lab=#net1}
N -210 -140 -210 -120 {
lab=#net1}
N -10 -270 -10 -260 {
lab=GND}
N -10 -140 -10 -120 {
lab=#net1}
N -610 -290 -610 -260 {
lab=#net18}
N -210 -290 -210 -260 {
lab=#net18}
N 250 -120 350 -120 {
lab=#net8}
N 350 -120 450 -120 {
lab=#net8}
N 250 -140 250 -120 {
lab=#net8}
N 450 -270 450 -260 {
lab=GND}
N 450 -140 450 -120 {
lab=#net8}
N 450 -270 510 -270 {
lab=GND}
N 250 -290 250 -260 {
lab=#net18}
N -10 -270 450 -270 {
lab=GND}
N -880 -270 -10 -270 {
lab=GND}
N -1310 -270 -880 -270 {
lab=GND}
N -2630 -270 -1310 -270 {
lab=GND}
N -3080 -270 -2630 -270 {
lab=GND}
N -3710 320 -3680 320 {
lab=GND}
N -3640 140 -3610 140 {
lab=GND}
N -3640 -50 -3610 -50 {
lab=GND}
N -3170 310 -3070 310 {
lab=#net9}
N -3270 310 -3170 310 {
lab=#net9}
N -3070 310 -3070 330 {
lab=#net9}
N -3270 310 -3270 330 {
lab=#net9}
N -3270 450 -3270 470 {
lab=#net17}
N -3070 450 -3070 500 {
lab=GND}
N -2720 310 -2620 310 {
lab=#net10}
N -2820 310 -2720 310 {
lab=#net10}
N -2620 310 -2620 330 {
lab=#net10}
N -2820 310 -2820 330 {
lab=#net10}
N -2820 450 -2820 470 {
lab=#net17}
N -2620 450 -2620 500 {
lab=GND}
N -2270 310 -2170 310 {
lab=#net11}
N -2370 310 -2270 310 {
lab=#net11}
N -2170 310 -2170 330 {
lab=#net11}
N -2370 310 -2370 330 {
lab=#net11}
N -2370 450 -2370 470 {
lab=#net17}
N -2170 450 -2170 500 {
lab=GND}
N -1820 310 -1720 310 {
lab=#net12}
N -1920 310 -1820 310 {
lab=#net12}
N -1720 310 -1720 330 {
lab=#net12}
N -1920 310 -1920 330 {
lab=#net12}
N -1920 450 -1920 470 {
lab=#net17}
N -1720 450 -1720 500 {
lab=GND}
N -1400 310 -1300 310 {
lab=#net13}
N -1500 310 -1400 310 {
lab=#net13}
N -1300 310 -1300 330 {
lab=#net13}
N -1500 310 -1500 330 {
lab=#net13}
N -1500 450 -1500 470 {
lab=#net17}
N -1300 450 -1300 500 {
lab=GND}
N -960 310 -860 310 {
lab=#net14}
N -1060 310 -960 310 {
lab=#net14}
N -860 310 -860 330 {
lab=#net14}
N -1060 310 -1060 330 {
lab=#net14}
N -1060 450 -1060 470 {
lab=#net17}
N -860 450 -860 500 {
lab=GND}
N -520 310 -420 310 {
lab=#net15}
N -620 310 -520 310 {
lab=#net15}
N -420 310 -420 330 {
lab=#net15}
N -620 310 -620 330 {
lab=#net15}
N -620 450 -620 470 {
lab=#net17}
N -420 450 -420 500 {
lab=GND}
N -90 310 10 310 {
lab=#net16}
N -190 310 -90 310 {
lab=#net16}
N 10 310 10 330 {
lab=#net16}
N -190 310 -190 330 {
lab=#net16}
N -190 450 -190 470 {
lab=#net17}
N 10 450 10 500 {
lab=GND}
N -3070 500 510 500 {
lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} -100 -50 2 0 {name=C1 model=cap_mim_m3_1 W=7 L=7 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -520 -50 2 0 {name=C2 model=cap_mim_m3_1 W=7 L=7 MF=2 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -970 -50 2 0 {name=C3 model=cap_mim_m3_1 W=7 L=7 MF=4 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1410 -50 2 0 {name=C4 model=cap_mim_m3_1 W=7 L=7 MF=8 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1830 -50 2 0 {name=C5 model=cap_mim_m3_1 W=7 L=7 MF=16 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2280 -50 2 0 {name=C6 model=cap_mim_m3_1 W=7 L=7 MF=32 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2730 -50 2 0 {name=C7 model=cap_mim_m3_1 W=7 L=7 MF=64 spiceprefix=X}
C {lab_pin.sym} -3230 -220 2 0 {name=p31 sig_type=std_logic lab=dx7}
C {sky130_fd_pr/cap_mim_m3_1.sym} 350 -50 2 0 {name=C9 model=cap_mim_m3_1 W=7 L=7 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3180 240 0 1 {name=C10 model=cap_mim_m3_1 W=7 L=7 MF=128 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2730 240 0 1 {name=C11 model=cap_mim_m3_1 W=7 L=7 MF=64 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2280 240 0 1 {name=C12 model=cap_mim_m3_1 W=7 L=7 MF=32 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1830 240 0 1 {name=C13 model=cap_mim_m3_1 W=7 L=7 MF=16 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1410 240 0 1 {name=C14 model=cap_mim_m3_1 W=7 L=7 MF=8 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -970 240 0 1 {name=C15 model=cap_mim_m3_1 W=7 L=7 MF=4 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -520 240 0 1 {name=C16 model=cap_mim_m3_1 W=7 L=7 MF=2 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} -100 240 0 1 {name=C17 model=cap_mim_m3_1 W=7 L=7 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 350 240 0 1 {name=C18 model=cap_mim_m3_1 W=7 L=7 MF=1 spiceprefix=X}
C {lab_pin.sym} -3730 -440 1 0 {name=p76 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} -3730 520 1 0 {name=p79 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} -3700 0 0 0 {name=p85 sig_type=std_logic lab=vcm}
C {lab_pin.sym} -3700 190 0 0 {name=p86 sig_type=std_logic lab=vcm}
C {lab_pin.sym} -3770 -390 0 0 {name=p87 sig_type=std_logic lab=vref}
C {lab_pin.sym} -3770 570 0 0 {name=p88 sig_type=std_logic lab=vref}
C {lab_pin.sym} -3760 -190 0 0 {name=p90 sig_type=std_logic lab=vinp}
C {vsource.sym} -110 780 0 0 {name=Vdd8 value="pulse(1.8 0 1n 1n 1n 50n 100u 1)" savecurrent=false}
C {gnd.sym} -110 810 0 0 {name=l6 lab=GND}
C {vsource.sym} -320 780 0 0 {name=Vdd4 value="pulse(0 1.8 1n 1n 1n 500n 1u)" savecurrent=false}
C {gnd.sym} -320 810 0 0 {name=l7 lab=GND}
C {lab_pin.sym} -320 750 1 0 {name=p98 sig_type=std_logic lab=clk}
C {lab_pin.sym} -110 750 1 0 {name=p99 sig_type=std_logic lab=rst_n}
C {devices/code.sym} -3210 -1500 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/code_shown.sym} -3050 -1660 0 0 {name=STIMULI
only_toplevel=true
value="
.tran 10n 20u
.save all
.param vcc = 1.8
.param vdd = 1.8
.param vdiff = 500m
vvcc vcc 0 dc vcc
vvdd vdd 0 dc vdd
vvss vss 0 0
.control

run
plot comp_p comp_m
plot d0+2 d1+4 d2+6 d3+8 d4+10 d5+12 d6+14 d7+16 data_rdy+18
write sar_tb.raw comp_p comp_m
set wr_singlescale
set wr_vecnames
wrdata sar.txt comp_p comp_m
.endc
"}
C {code.sym} -3350 -1500 0 0 {name=SWITCH1 only_toplevel=false value=".model SWITCH1 sw vt=0.9 vh=0 ron=1 roff =100G"}
C {gnd.sym} 510 -270 0 0 {name=l2 lab=GND}
C {lab_pin.sym} -3130 -1160 0 0 {name=p104 sig_type=std_logic lab=data[7..0]}
C {vsource.sym} -560 780 0 0 {name=Vdd1 value=1.8 savecurrent=false}
C {gnd.sym} -560 810 0 0 {name=l3 lab=GND}
C {lab_pin.sym} -560 750 1 0 {name=p107 sig_type=std_logic lab=vref}
C {lab_pin.sym} 660 0 0 1 {name=p111 sig_type=std_logic lab=comp_p}
C {lab_pin.sym} 660 190 0 1 {name=p112 sig_type=std_logic lab=comp_m}
C {lab_pin.sym} -3700 -240 3 1 {name=p135 sig_type=std_logic lab=smpl}
C {lab_pin.sym} -2430 -980 3 0 {name=p136 sig_type=std_logic lab=d[7..0]}
C {sky130_fd_pr/cap_mim_m3_1.sym} -3180 -50 2 0 {name=C8 model=cap_mim_m3_1 W=7 L=7 MF=128 spiceprefix=X}
C {/foss/designs/Behavioural module/Behavioural module/comp_behavioral.sym} 810 90 0 0 {name=x1 OFFSET=0.9 AMPLITUDE=1.8 GAIN=100000 ROUT=00 COUT=0}
C {sky130_stdcells/inv_8.sym} 950 90 0 0 {name=x3 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} 990 90 2 0 {name=p110 sig_type=std_logic lab=comp_out}
C {gnd.sym} 510 500 0 0 {name=l1 lab=GND}
C {lab_pin.sym} -3770 370 0 0 {name=p89 sig_type=std_logic lab=vinm}
C {gnd.sym} -3650 -240 2 0 {name=l57 lab=GND
value=0.6}
C {/foss/designs/test/design/sar_controller.sym} -3880 -1010 0 0 {name=x2}
C {lab_pin.sym} -4030 -1070 0 0 {name=p1 sig_type=std_logic lab=clk}
C {lab_pin.sym} -4030 -1050 0 0 {name=p4 sig_type=std_logic lab=rst_n}
C {lab_pin.sym} -4030 -1030 0 0 {name=p5 sig_type=std_logic lab=comp_out}
C {lab_pin.sym} -3730 -1070 2 0 {name=p6 sig_type=std_logic lab=data_rdy}
C {lab_pin.sym} -3730 -1050 2 0 {name=p9 sig_type=std_logic lab=smpl}
C {lab_pin.sym} -3730 -1030 2 0 {name=p10 sig_type=std_logic lab=smpl_n}
C {lab_pin.sym} -3730 -990 2 0 {name=p13 sig_type=std_logic lab=supply}
C {lab_pin.sym} -3730 -970 2 0 {name=p14 sig_type=std_logic lab=data[7..0]}
C {lab_pin.sym} -3730 -950 2 0 {name=p17 sig_type=std_logic lab=data_n[7..0]}
C {gnd.sym} -3730 -1010 3 0 {name=l18 lab=GND}
C {vsource.sym} -650 780 0 0 {name=Vdd5 value=1.8 savecurrent=false}
C {gnd.sym} -650 810 0 0 {name=l19 lab=GND}
C {lab_pin.sym} -650 750 1 0 {name=p18 sig_type=std_logic lab=supply}
C {devices/vsource.sym} -1040 840 0 0 {name=V_VCM_2 value=0.9}
C {devices/gnd.sym} -1040 880 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -1040 800 0 0 {name=l11 sig_type=std_logic lab=vcm}
C {devices/vsource.sym} -1100 720 0 0 {name=V_VCM_1 value=\{vdiff/2\}}
C {devices/vsource.sym} -980 720 2 1 {name=V_VCM_3 value=\{vdiff/2\}}
C {lab_pin.sym} -980 690 1 0 {name=p21 sig_type=std_logic lab=vinm}
C {lab_pin.sym} -1100 690 1 0 {name=p22 sig_type=std_logic lab=vinp}
C {sky130_stdcells/inv_2.sym} -3100 -1100 1 0 {name=x21[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/nor2_1.sym} -2880 -1140 0 0 {name=x22[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/nor2_1.sym} -2880 -980 0 0 {name=x23[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2740 -1140 0 0 {name=x24[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2620 -1140 0 0 {name=x25[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2510 -1140 0 0 {name=x26[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2740 -980 0 0 {name=x27[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2620 -980 0 0 {name=x28[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2510 -980 0 0 {name=x29[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -2360 -1140 0 0 {name=x30[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_2.sym} -2360 -980 0 0 {name=x31[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2320 -980 2 0 {name=p45 sig_type=std_logic lab=d_n[7..0]}
C {lab_pin.sym} -2430 -1140 3 0 {name=p42 sig_type=std_logic lab=dn[7..0]}
C {lab_pin.sym} -2320 -1140 2 0 {name=p49 sig_type=std_logic lab=dn_n[7..0]}
C {sky130_stdcells/or2_1.sym} -2300 -780 0 0 {name=x1[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -3640 -760 0 0 {name=p30 sig_type=std_logic lab=smpl}
C {sky130_stdcells/buf_1.sym} -3600 -760 0 0 {name=x21 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3510 -760 0 0 {name=x22 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3420 -760 0 0 {name=x23 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3330 -760 0 0 {name=x24 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3240 -760 0 0 {name=x25 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3150 -760 0 0 {name=x26 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2240 -780 1 0 {name=p37 sig_type=std_logic lab=dx[7..0]}
C {sky130_stdcells/inv_2.sym} -2190 -780 0 0 {name=x2[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2150 -780 2 0 {name=p38 sig_type=std_logic lab=dx_n[7..0]}
C {sky130_stdcells/and2_2.sym} -2300 -1270 0 0 {name=x12[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2360 -1290 0 0 {name=p26 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} -2240 -1270 2 0 {name=p41 sig_type=std_logic lab=dnx[7..0]}
C {sky130_stdcells/buf_1.sym} -3040 -760 0 0 {name=x4 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2950 -760 0 0 {name=x5 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2860 -760 0 0 {name=x6 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2770 -760 0 0 {name=x18 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_2.sym} -2680 -760 0 0 {name=x19 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_4.sym} -2570 -760 0 0 {name=x20 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_6.sym} -2480 -760 0 0 {name=x27 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_8.sym} -1730 -680 0 0 {name=x28 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -1690 -680 2 0 {name=p33 sig_type=std_logic lab=smpl_n_d12}
C {sky130_stdcells/buf_1.sym} -2350 -680 0 0 {name=x29 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2260 -680 0 0 {name=x30 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2170 -680 0 0 {name=x31 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_2.sym} -2080 -680 0 0 {name=x32 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_4.sym} -1970 -680 0 0 {name=x33 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_6.sym} -1880 -680 0 0 {name=x34 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {/home/imasha/saradcnew/tg_sym.sym} -3680 -220 3 0 {name=x7}
C {lab_pin.sym} -3670 -140 3 0 {name=p25 sig_type=std_logic lab=supply}
C {gnd.sym} -3710 -440 3 0 {name=l4 lab=GND
value=0.6}
C {lab_pin.sym} -3700 -340 3 0 {name=p46 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -3710 -420 3 0 {name=x8}
C {gnd.sym} -3230 -200 0 0 {name=l5 lab=GND
value=0.6}
C {lab_pin.sym} -3330 -190 0 0 {name=p29 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -3250 -200 0 0 {name=x9}
C {lab_pin.sym} -3030 -220 2 0 {name=p32 sig_type=std_logic lab=dnx7}
C {gnd.sym} -3030 -200 0 0 {name=l8 lab=GND
value=0.6}
C {lab_pin.sym} -3130 -190 0 0 {name=p34 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -3050 -200 0 0 {name=x10}
C {lab_pin.sym} -2780 -220 2 0 {name=p27 sig_type=std_logic lab=dx6}
C {gnd.sym} -2780 -200 0 0 {name=l9 lab=GND
value=0.6}
C {lab_pin.sym} -2880 -190 0 0 {name=p50 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -2800 -200 0 0 {name=x11}
C {lab_pin.sym} -2580 -220 2 0 {name=p28 sig_type=std_logic lab=dnx6}
C {gnd.sym} -2580 -200 0 0 {name=l12 lab=GND
value=0.6}
C {lab_pin.sym} -2680 -190 0 0 {name=p53 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -2600 -200 0 0 {name=x12}
C {lab_pin.sym} -2330 -220 2 0 {name=p23 sig_type=std_logic lab=dx5}
C {gnd.sym} -2330 -200 0 0 {name=l13 lab=GND
value=0.6}
C {lab_pin.sym} -2430 -190 0 0 {name=p24 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -2350 -200 0 0 {name=x13}
C {lab_pin.sym} -2130 -220 2 0 {name=p54 sig_type=std_logic lab=dnx5}
C {gnd.sym} -2130 -200 0 0 {name=l14 lab=GND
value=0.6}
C {lab_pin.sym} -2230 -190 0 0 {name=p57 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -2150 -200 0 0 {name=x14}
C {lab_pin.sym} -1870 -220 2 0 {name=p19 sig_type=std_logic lab=dx4}
C {gnd.sym} -1870 -200 0 0 {name=l15 lab=GND
value=0.6}
C {lab_pin.sym} -1970 -190 0 0 {name=p20 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -1890 -200 0 0 {name=x15}
C {lab_pin.sym} -1670 -220 2 0 {name=p58 sig_type=std_logic lab=dnx4}
C {gnd.sym} -1670 -200 0 0 {name=l16 lab=GND
value=0.6}
C {lab_pin.sym} -1770 -190 0 0 {name=p61 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -1690 -200 0 0 {name=x16}
C {lab_pin.sym} -1450 -220 2 0 {name=p11 sig_type=std_logic lab=dx3}
C {gnd.sym} -1450 -200 0 0 {name=l17 lab=GND
value=0.6}
C {lab_pin.sym} -1550 -190 0 0 {name=p12 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -1470 -200 0 0 {name=x17}
C {lab_pin.sym} -1250 -220 2 0 {name=p15 sig_type=std_logic lab=dnx3}
C {gnd.sym} -1250 -200 0 0 {name=l20 lab=GND
value=0.6}
C {lab_pin.sym} -1350 -190 0 0 {name=p16 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -1270 -200 0 0 {name=x35}
C {lab_pin.sym} -1020 -220 2 0 {name=p62 sig_type=std_logic lab=dx2}
C {gnd.sym} -1020 -200 0 0 {name=l21 lab=GND
value=0.6}
C {lab_pin.sym} -1120 -190 0 0 {name=p65 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -1040 -200 0 0 {name=x36}
C {lab_pin.sym} -820 -220 2 0 {name=p66 sig_type=std_logic lab=dnx2}
C {gnd.sym} -820 -200 0 0 {name=l22 lab=GND
value=0.6}
C {lab_pin.sym} -920 -190 0 0 {name=p69 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -840 -200 0 0 {name=x37}
C {lab_pin.sym} -560 -220 2 0 {name=p2 sig_type=std_logic lab=dx1}
C {gnd.sym} -560 -200 0 0 {name=l23 lab=GND
value=0.6}
C {lab_pin.sym} -660 -190 0 0 {name=p3 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -580 -200 0 0 {name=x38}
C {lab_pin.sym} -360 -220 2 0 {name=p7 sig_type=std_logic lab=dnx1}
C {gnd.sym} -360 -200 0 0 {name=l24 lab=GND
value=0.6}
C {lab_pin.sym} -460 -190 0 0 {name=p8 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -380 -200 0 0 {name=x39}
C {lab_pin.sym} -160 -220 2 0 {name=p70 sig_type=std_logic lab=dx0
}
C {gnd.sym} -160 -200 0 0 {name=l25 lab=GND
value=0.6}
C {lab_pin.sym} -260 -190 0 0 {name=p71 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -180 -200 0 0 {name=x40}
C {lab_pin.sym} 40 -220 2 0 {name=p72 sig_type=std_logic lab=dnx0}
C {gnd.sym} 40 -200 0 0 {name=l26 lab=GND
value=0.6}
C {lab_pin.sym} -60 -190 0 0 {name=p73 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} 20 -200 0 0 {name=x41}
C {gnd.sym} 300 -200 0 0 {name=l27 lab=GND
value=0.6}
C {lab_pin.sym} 200 -190 0 0 {name=p36 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} 280 -200 0 0 {name=x42}
C {gnd.sym} 500 -200 0 0 {name=l28 lab=GND
value=0.6}
C {lab_pin.sym} 400 -190 0 0 {name=p75 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} 480 -200 0 0 {name=x43}
C {lab_pin.sym} 300 -220 0 1 {name=p77 sig_type=std_logic lab=smpl}
C {lab_pin.sym} 500 -220 2 0 {name=p35 sig_type=std_logic lab=smpl_n_d12}
C {gnd.sym} -3710 520 3 0 {name=l29 lab=GND
value=0.6}
C {lab_pin.sym} -3700 620 3 0 {name=p78 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -3710 540 3 0 {name=x44}
C {lab_pin.sym} -3730 320 3 1 {name=p74 sig_type=std_logic lab=smpl}
C {gnd.sym} -3680 320 2 0 {name=l30 lab=GND
value=0.6}
C {/home/imasha/saradcnew/tg_sym.sym} -3710 340 3 0 {name=x45}
C {lab_pin.sym} -3700 420 3 0 {name=p80 sig_type=std_logic lab=supply}
C {lab_pin.sym} -3660 140 3 1 {name=p81 sig_type=std_logic lab=smpl}
C {gnd.sym} -3610 140 2 0 {name=l31 lab=GND
value=0.6}
C {/home/imasha/saradcnew/tg_sym.sym} -3640 160 3 0 {name=x46}
C {lab_pin.sym} -3630 240 3 0 {name=p83 sig_type=std_logic lab=supply}
C {lab_pin.sym} -3660 -50 2 1 {name=p82 sig_type=std_logic lab=smpl}
C {gnd.sym} -3610 -50 2 0 {name=l32 lab=GND
value=0.6}
C {/home/imasha/saradcnew/tg_sym.sym} -3640 -30 3 0 {name=x47}
C {lab_pin.sym} -3630 50 3 0 {name=p84 sig_type=std_logic lab=supply}
C {lab_pin.sym} -3120 410 0 0 {name=p39 sig_type=std_logic lab=d7}
C {gnd.sym} -3120 390 2 0 {name=l35 lab=GND
value=0.6}
C {lab_pin.sym} -3020 380 2 0 {name=p40 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -3100 390 2 0 {name=x50}
C {lab_pin.sym} -3320 410 0 0 {name=p95 sig_type=std_logic lab=dn7}
C {gnd.sym} -3320 390 2 0 {name=l36 lab=GND
value=0.6}
C {lab_pin.sym} -3220 380 2 0 {name=p96 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -3300 390 2 0 {name=x51}
C {lab_pin.sym} -2670 410 0 0 {name=p43 sig_type=std_logic lab=d6}
C {gnd.sym} -2670 390 2 0 {name=l37 lab=GND
value=0.6}
C {lab_pin.sym} -2570 380 2 0 {name=p44 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -2650 390 2 0 {name=x52}
C {lab_pin.sym} -2870 410 0 0 {name=p97 sig_type=std_logic lab=dn6}
C {gnd.sym} -2870 390 2 0 {name=l38 lab=GND
value=0.6}
C {lab_pin.sym} -2770 380 2 0 {name=p100 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -2850 390 2 0 {name=x53}
C {lab_pin.sym} -2220 410 0 0 {name=p47 sig_type=std_logic lab=d5}
C {gnd.sym} -2220 390 2 0 {name=l39 lab=GND
value=0.6}
C {lab_pin.sym} -2120 380 2 0 {name=p48 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -2200 390 2 0 {name=x54}
C {lab_pin.sym} -2420 410 0 0 {name=p101 sig_type=std_logic lab=dn5}
C {gnd.sym} -2420 390 2 0 {name=l50 lab=GND
value=0.6}
C {lab_pin.sym} -2320 380 2 0 {name=p102 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -2400 390 2 0 {name=x55}
C {lab_pin.sym} -1770 410 0 0 {name=p51 sig_type=std_logic lab=d4}
C {gnd.sym} -1770 390 2 0 {name=l48 lab=GND
value=0.6}
C {lab_pin.sym} -1670 380 2 0 {name=p52 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -1750 390 2 0 {name=x56}
C {lab_pin.sym} -1970 410 0 0 {name=p103 sig_type=std_logic lab=dn4}
C {gnd.sym} -1970 390 2 0 {name=l49 lab=GND
value=0.6}
C {lab_pin.sym} -1870 380 2 0 {name=p105 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -1950 390 2 0 {name=x57}
C {lab_pin.sym} -1350 410 0 0 {name=p55 sig_type=std_logic lab=d3}
C {gnd.sym} -1350 390 2 0 {name=l46 lab=GND
value=0.6}
C {lab_pin.sym} -1250 380 2 0 {name=p56 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -1330 390 2 0 {name=x58}
C {lab_pin.sym} -1550 410 0 0 {name=p106 sig_type=std_logic lab=dn3}
C {gnd.sym} -1550 390 2 0 {name=l47 lab=GND
value=0.6}
C {lab_pin.sym} -1450 380 2 0 {name=p108 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -1530 390 2 0 {name=x59}
C {lab_pin.sym} -910 410 0 0 {name=p59 sig_type=std_logic lab=d2}
C {gnd.sym} -910 390 2 0 {name=l44 lab=GND
value=0.6}
C {lab_pin.sym} -810 380 2 0 {name=p60 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -890 390 2 0 {name=x60}
C {lab_pin.sym} -1110 410 0 0 {name=p109 sig_type=std_logic lab=dn2}
C {gnd.sym} -1110 390 2 0 {name=l45 lab=GND
value=0.6}
C {lab_pin.sym} -1010 380 2 0 {name=p113 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -1090 390 2 0 {name=x61}
C {lab_pin.sym} -470 410 0 0 {name=p63 sig_type=std_logic lab=d1}
C {gnd.sym} -470 390 2 0 {name=l42 lab=GND
value=0.6}
C {lab_pin.sym} -370 380 2 0 {name=p64 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -450 390 2 0 {name=x62}
C {lab_pin.sym} -670 410 0 0 {name=p114 sig_type=std_logic lab=dn1}
C {gnd.sym} -670 390 2 0 {name=l43 lab=GND
value=0.6}
C {lab_pin.sym} -570 380 2 0 {name=p115 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -650 390 2 0 {name=x63}
C {lab_pin.sym} -40 410 0 0 {name=p67 sig_type=std_logic lab=d0}
C {gnd.sym} -40 390 2 0 {name=l40 lab=GND
value=0.6}
C {lab_pin.sym} 60 380 2 0 {name=p68 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -20 390 2 0 {name=x64}
C {lab_pin.sym} -240 410 0 0 {name=p116 sig_type=std_logic lab=dn0}
C {gnd.sym} -240 390 2 0 {name=l41 lab=GND
value=0.6}
C {lab_pin.sym} -140 380 2 0 {name=p117 sig_type=std_logic lab=supply}
C {/home/imasha/saradcnew/tg_sym.sym} -220 390 2 0 {name=x65}
