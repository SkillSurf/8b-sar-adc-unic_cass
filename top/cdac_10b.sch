v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_wire.sym} 360 -310 0 0 {name=p2 sig_type=std_logic lab=vdref}
C {devices/lab_wire.sym} 360 -230 0 0 {name=p3 sig_type=std_logic lab=vsref}
C {devices/lab_wire.sym} 360 -250 0 0 {name=p11 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 360 -290 0 0 {name=p13 sig_type=std_logic lab=cf[0:9]}
C {devices/lab_wire.sym} 360 -270 0 0 {name=p14 sig_type=std_logic lab=swp_in[0:9]}
C {devices/lab_wire.sym} 660 -310 0 1 {name=p16 sig_type=std_logic lab=vcp}
C {devices/lab_wire.sym} 660 -180 0 1 {name=p17 sig_type=std_logic lab=vcn}
C {devices/ipin.sym} 160 -320 0 0 {name=p18 lab=vdref}
C {devices/ipin.sym} 160 -290 0 0 {name=p19 lab=cf[0:9]}
C {devices/ipin.sym} 160 -260 0 0 {name=p20 lab=swp_in[0:9]}
C {devices/ipin.sym} 160 -230 0 0 {name=p21 lab=swn_in[0:9]}
C {devices/ipin.sym} 160 -200 0 0 {name=p22 lab=vcm}
C {devices/ipin.sym} 160 -170 0 0 {name=p23 lab=vsref}
C {devices/iopin.sym} 140 -140 0 0 {name=p24 lab=vcp}
C {devices/iopin.sym} 140 -110 0 0 {name=p25 lab=vcn}
C {single_10b_cdac.sym} 510 -270 0 0 {name=x3}
C {devices/lab_wire.sym} 360 -180 0 0 {name=p5 sig_type=std_logic lab=vdref}
C {devices/lab_wire.sym} 360 -100 0 0 {name=p75 sig_type=std_logic lab=vsref}
C {devices/lab_wire.sym} 360 -120 0 0 {name=p76 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 360 -160 0 0 {name=p77 sig_type=std_logic lab=cf[0:9]}
C {devices/lab_wire.sym} 360 -140 0 0 {name=p78 sig_type=std_logic lab=swn_in[0:9]}
C {single_10b_cdac.sym} 510 -140 0 0 {name=x4}
C {devices/lab_wire.sym} 800 -310 0 0 {name=p1 sig_type=std_logic lab=vdref}
C {devices/lab_wire.sym} 800 -230 0 0 {name=p4 sig_type=std_logic lab=vsref}
C {devices/lab_wire.sym} 800 -250 0 0 {name=p6 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 800 -290 0 0 {name=p7 sig_type=std_logic lab=cf[0:9]}
C {devices/lab_wire.sym} 800 -270 0 0 {name=p8 sig_type=std_logic lab=swp_in[0:9]}
C {devices/lab_wire.sym} 1100 -310 0 1 {name=p9 sig_type=std_logic lab=vcp}
C {devices/lab_wire.sym} 1100 -180 0 1 {name=p10 sig_type=std_logic lab=vcn}
C {single_10b_cdac.sym} 950 -270 0 0 {name=x1}
C {devices/lab_wire.sym} 800 -180 0 0 {name=p12 sig_type=std_logic lab=vdref}
C {devices/lab_wire.sym} 800 -100 0 0 {name=p15 sig_type=std_logic lab=vsref}
C {devices/lab_wire.sym} 800 -120 0 0 {name=p26 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 800 -160 0 0 {name=p27 sig_type=std_logic lab=cf[0:9]}
C {devices/lab_wire.sym} 800 -140 0 0 {name=p28 sig_type=std_logic lab=swn_in[0:9]}
C {single_10b_cdac.sym} 950 -140 0 0 {name=x2}
