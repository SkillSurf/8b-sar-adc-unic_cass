v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_stdcells/dfrtp_2.sym} 390 -230 0 0 {name=x1[0:9] VGND=VSSD VNB=VSSD VPB=VDDD VPWR=VDDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 300 -230 0 0 {name=p2 sig_type=std_logic lab=SWP[0:9]}
C {devices/lab_wire.sym} 480 -250 0 1 {name=p1 sig_type=std_logic lab=DOUT[0:9]}
C {devices/lab_wire.sym} 300 -210 0 0 {name=p3 sig_type=std_logic lab=EN}
C {devices/lab_wire.sym} 300 -250 0 0 {name=p4 sig_type=std_logic lab=CK}
C {devices/lab_wire.sym} 310 -130 0 0 {name=p5 sig_type=std_logic lab=FINAL}
C {devices/lab_wire.sym} 310 -90 0 0 {name=p6 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 430 -110 0 1 {name=p7 sig_type=std_logic lab=CK}
C {devices/ipin.sym} 100 -240 0 0 {name=p15 sig_type=std_logic lab=VDDD}
C {devices/ipin.sym} 100 -160 0 0 {name=p16 sig_type=std_logic lab=CLKS}
C {devices/ipin.sym} 100 -140 0 0 {name=p17 sig_type=std_logic lab=VSSD}
C {devices/ipin.sym} 100 -220 0 0 {name=p8 sig_type=std_logic lab=FINAL}
C {devices/ipin.sym} 100 -200 0 0 {name=p9 sig_type=std_logic lab=SWP[0:9]}
C {devices/opin.sym} 100 -100 0 0 {name=p10 sig_type=std_logic lab=DOUT[0:9]}
C {devices/opin.sym} 100 -80 0 0 {name=p11 sig_type=std_logic lab=CK}
C {sky130_stdcells/and2_1.sym} 370 -110 0 0 {name=x1 VGND=VSSD VNB=VSSD VPB=VDDD VPWR=VDDD prefix=sky130_fd_sc_hd__ }
C {devices/ipin.sym} 100 -180 0 0 {name=p12 sig_type=std_logic lab=EN}
