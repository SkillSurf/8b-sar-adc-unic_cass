v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_wire.sym} 280 -450 0 0 {name=p1 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 280 -370 0 0 {name=p2 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 280 -430 0 0 {name=p3 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 280 -410 0 0 {name=p4 sig_type=std_logic lab=CLKSB}
C {devices/lab_wire.sym} 280 -390 0 0 {name=p5 sig_type=std_logic lab=VIP}
C {devices/lab_wire.sym} 280 -290 0 0 {name=p6 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 280 -210 0 0 {name=p7 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 280 -270 0 0 {name=p8 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 280 -250 0 0 {name=p9 sig_type=std_logic lab=CLKSB}
C {devices/lab_wire.sym} 280 -230 0 0 {name=p10 sig_type=std_logic lab=VIN}
C {devices/lab_wire.sym} 580 -450 0 1 {name=p11 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 580 -290 0 1 {name=p12 sig_type=std_logic lab=VCN}
C {devices/ipin.sym} 100 -460 0 0 {name=p13 sig_type=std_logic lab=VDDA}
C {devices/ipin.sym} 100 -440 0 0 {name=p14 sig_type=std_logic lab=CLKS}
C {devices/ipin.sym} 100 -420 0 0 {name=p15 sig_type=std_logic lab=CLKSB}
C {devices/ipin.sym} 100 -400 0 0 {name=p16 sig_type=std_logic lab=VIP}
C {devices/ipin.sym} 100 -380 0 0 {name=p17 sig_type=std_logic lab=VIN}
C {devices/ipin.sym} 100 -360 0 0 {name=p18 sig_type=std_logic lab=VSSA}
C {devices/iopin.sym} 80 -340 0 0 {name=p19 sig_type=std_logic lab=VCP}
C {devices/iopin.sym} 80 -320 0 0 {name=p20 sig_type=std_logic lab=VCN}
C {/foss/designs/bsw.sym} 430 -410 0 0 {name=x3}
C {/foss/designs/bsw.sym} 430 -250 0 0 {name=x1}
