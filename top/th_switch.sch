v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {bsw.sym} 530 -450 0 0 {name=x1}
C {bsw.sym} 530 -290 0 0 {name=x2}
C {lab_wire.sym} 380 -490 0 0 {name=p1 sig_type=std_logic lab=vdda}
C {lab_wire.sym} 380 -330 0 0 {name=p2 sig_type=std_logic lab=vdda}
C {lab_wire.sym} 380 -250 0 0 {name=p3 sig_type=std_logic lab=vssa}
C {lab_wire.sym} 380 -410 0 0 {name=p4 sig_type=std_logic lab=vssa}
C {lab_wire.sym} 380 -470 0 0 {name=p5 sig_type=std_logic lab=clk}
C {lab_wire.sym} 380 -450 0 0 {name=p6 sig_type=std_logic lab=clkb}
C {lab_wire.sym} 380 -310 0 0 {name=p7 sig_type=std_logic lab=clk}
C {lab_wire.sym} 380 -290 0 0 {name=p8 sig_type=std_logic lab=clkb}
C {lab_wire.sym} 380 -430 0 0 {name=p9 sig_type=std_logic lab=vip}
C {lab_wire.sym} 380 -270 0 0 {name=p10 sig_type=std_logic lab=vin}
C {lab_wire.sym} 680 -490 0 1 {name=p11 sig_type=std_logic lab=vcp}
C {lab_wire.sym} 680 -330 0 1 {name=p12 sig_type=std_logic lab=vcn}
C {ipin.sym} 240 -500 0 0 {name=p13 lab=vdda}
C {ipin.sym} 240 -480 0 0 {name=p14 lab=clk}
C {ipin.sym} 240 -460 0 0 {name=p15 lab=clkb}
C {ipin.sym} 240 -440 0 0 {name=p16 lab=vip}
C {ipin.sym} 240 -420 0 0 {name=p17 lab=vin}
C {ipin.sym} 240 -400 0 0 {name=p18 lab=vssa}
C {opin.sym} 220 -360 0 0 {name=p19 lab=vcp}
C {opin.sym} 220 -340 0 0 {name=p20 lab=vcn}
