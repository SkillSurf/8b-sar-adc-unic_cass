v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sar_8bit.sym} -40 -230 0 0 {name=x1}
C {opin.sym} 160 150 2 1 {name=p1 lab=M_DATA_RDY
}
C {iopin.sym} 80 50 3 0 {name=p4 lab=M_AVSS
}
C {ipin.sym} -60 50 1 0 {name=p21 lab=M_CLK


}
C {ipin.sym} -40 50 1 0 {name=p22 lab=M_RST_N



}
C {opin.sym} 160 170 2 1 {name=p85 lab=M_DOUT[7..0]
}
C {iopin.sym} 120 50 3 0 {name=p66 lab=M_DVSS
}
C {iopin.sym} 100 50 3 0 {name=p71 lab=M_DVDD}
C {ipin.sym} -160 130 2 1 {name=p86 lab=M_VINP
}
C {ipin.sym} -160 210 2 1 {name=p87 lab=M_VINM
}
C {ipin.sym} -200 170 2 1 {name=p88 lab=M_VCM
}
C {ipin.sym} -130 100 2 1 {name=p89 lab=M_VREFP
}
C {ipin.sym} 40 50 3 1 {name=p91 lab=M_IBSNK_1U
}
C {devices/ipin.sym} -140 410 0 0 {name=p37 sig_type=std_logic lab=A_VDDA}
C {devices/ipin.sym} -140 430 0 0 {name=p38 sig_type=std_logic lab=A_VDDD}
C {devices/ipin.sym} -140 450 0 0 {name=p39 sig_type=std_logic lab=A_VCM}
C {devices/ipin.sym} -140 490 0 0 {name=p40 sig_type=std_logic lab=A_CLK}
C {devices/ipin.sym} -140 510 0 0 {name=p41 sig_type=std_logic lab=A_VIP}
C {devices/ipin.sym} -140 530 0 0 {name=p42 sig_type=std_logic lab=A_VIN}
C {devices/ipin.sym} -140 570 0 0 {name=p43 sig_type=std_logic lab=A_VSSA}
C {devices/ipin.sym} -140 590 0 0 {name=p44 sig_type=std_logic lab=A_VSSD}
C {devices/opin.sym} 160 390 0 0 {name=p45 sig_type=std_logic lab=A_DOUT[0:9]}
C {devices/opin.sym} 160 410 0 0 {name=p46 sig_type=std_logic lab=A_CKO}
C {devices/ipin.sym} -140 550 0 0 {name=p14 sig_type=std_logic lab=A_VSSR}
C {devices/ipin.sym} -140 390 0 0 {name=p16 sig_type=std_logic lab=A_VDDR}
C {devices/ipin.sym} -140 470 0 0 {name=p49 sig_type=std_logic lab=A_EN}
C {devices/opin.sym} 160 430 0 0 {name=p50 sig_type=std_logic lab=A_COMP_P}
C {devices/opin.sym} 160 450 0 0 {name=p51 sig_type=std_logic lab=A_COMP_N}
C {iopin.sym} 60 50 3 0 {name=p2 lab=M_AVDD}
C {ipin.sym} -130 240 2 1 {name=p3 lab=M_VREFM
}
C {opin.sym} 160 190 2 1 {name=p5 lab=M_COMP_OUT
}
C {/foss/designs/10b_adc.sym} 10 490 0 0 {name=x2}
