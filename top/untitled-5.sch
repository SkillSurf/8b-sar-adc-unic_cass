v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 410 -310 410 -280 {
lab=#net1}
N 410 -280 510 -280 {
lab=#net1}
N 510 -280 510 -240 {
lab=#net1}
N 610 -310 610 -280 {
lab=#net1}
N 510 -280 610 -280 {
lab=#net1}
N -10 -310 -10 -280 {
lab=#net2}
N -10 -280 90 -280 {
lab=#net2}
N 90 -280 90 -240 {
lab=#net2}
N 190 -310 190 -280 {
lab=#net2}
N 90 -280 190 -280 {
lab=#net2}
N -460 -310 -460 -280 {
lab=#net3}
N -460 -280 -360 -280 {
lab=#net3}
N -360 -280 -360 -240 {
lab=#net3}
N -260 -310 -260 -280 {
lab=#net3}
N -360 -280 -260 -280 {
lab=#net3}
N -900 -310 -900 -280 {
lab=#net4}
N -900 -280 -800 -280 {
lab=#net4}
N -800 -280 -800 -240 {
lab=#net4}
N -700 -310 -700 -280 {
lab=#net4}
N -800 -280 -700 -280 {
lab=#net4}
N -1320 -310 -1320 -280 {
lab=#net5}
N -1320 -280 -1220 -280 {
lab=#net5}
N -1220 -280 -1220 -240 {
lab=#net5}
N -1120 -310 -1120 -280 {
lab=#net5}
N -1220 -280 -1120 -280 {
lab=#net5}
N -1770 -310 -1770 -280 {
lab=#net6}
N -1770 -280 -1670 -280 {
lab=#net6}
N -1670 -280 -1670 -240 {
lab=#net6}
N -1570 -310 -1570 -280 {
lab=#net6}
N -1670 -280 -1570 -280 {
lab=#net6}
N -2220 -310 -2220 -280 {
lab=#net7}
N -2220 -280 -2120 -280 {
lab=#net7}
N -2120 -280 -2120 -240 {
lab=#net7}
N -2020 -310 -2020 -280 {
lab=#net7}
N -2120 -280 -2020 -280 {
lab=#net7}
N -2670 -310 -2670 -280 {
lab=#net8}
N -2470 -310 -2470 -280 {
lab=#net8}
N 860 -310 860 -280 {
lab=#net9}
N 860 -280 960 -280 {
lab=#net9}
N 960 -280 960 -240 {
lab=#net9}
N 1060 -310 1060 -280 {
lab=#net9}
N 960 -280 1060 -280 {
lab=#net9}
N -2670 150 -2670 180 {
lab=#net10}
N -2670 150 -2570 150 {
lab=#net10}
N -2570 110 -2570 150 {
lab=#net10}
N -2470 150 -2470 180 {
lab=#net10}
N -2570 150 -2470 150 {
lab=#net10}
N -2220 150 -2220 180 {
lab=#net11}
N -2220 150 -2120 150 {
lab=#net11}
N -2120 110 -2120 150 {
lab=#net11}
N -2020 150 -2020 180 {
lab=#net11}
N -2120 150 -2020 150 {
lab=#net11}
N -1770 150 -1770 180 {
lab=#net12}
N -1770 150 -1670 150 {
lab=#net12}
N -1670 110 -1670 150 {
lab=#net12}
N -1570 150 -1570 180 {
lab=#net12}
N -1670 150 -1570 150 {
lab=#net12}
N -1320 150 -1320 180 {
lab=#net13}
N -1320 150 -1220 150 {
lab=#net13}
N -1220 110 -1220 150 {
lab=#net13}
N -1120 150 -1120 180 {
lab=#net13}
N -1220 150 -1120 150 {
lab=#net13}
N -900 150 -900 180 {
lab=#net14}
N -900 150 -800 150 {
lab=#net14}
N -800 110 -800 150 {
lab=#net14}
N -700 150 -700 180 {
lab=#net14}
N -800 150 -700 150 {
lab=#net14}
N -460 150 -460 180 {
lab=#net15}
N -460 150 -360 150 {
lab=#net15}
N -360 110 -360 150 {
lab=#net15}
N -260 150 -260 180 {
lab=#net15}
N -360 150 -260 150 {
lab=#net15}
N -10 150 -10 180 {
lab=#net16}
N -10 150 90 150 {
lab=#net16}
N 90 110 90 150 {
lab=#net16}
N 190 150 190 180 {
lab=#net16}
N 90 150 190 150 {
lab=#net16}
N 410 150 410 180 {
lab=#net17}
N 410 150 510 150 {
lab=#net17}
N 510 110 510 150 {
lab=#net17}
N 610 150 610 180 {
lab=#net17}
N 510 150 610 150 {
lab=#net17}
N 960 150 960 310 {
lab=#net18}
N 960 110 960 150 {
lab=#net18}
N -2570 -180 -2570 -160 {
lab=comp_p}
N 960 -180 960 -160 {
lab=comp_p}
N 510 -180 510 -160 {
lab=comp_p}
N 90 -180 90 -160 {
lab=comp_p}
N -360 -180 -360 -160 {
lab=comp_p}
N -800 -180 -800 -160 {
lab=comp_p}
N -1220 -180 -1220 -160 {
lab=comp_p}
N -1670 -180 -1670 -160 {
lab=comp_p}
N -2120 -180 -2120 -160 {
lab=comp_p}
N -2470 -420 -2470 -370 {
lab=GND}
N 1060 -420 1120 -420 {
lab=GND}
N -2020 -420 -2020 -370 {
lab=GND}
N -1570 -420 -1570 -370 {
lab=GND}
N -1120 -420 -1120 -370 {
lab=GND}
N -700 -420 -700 -370 {
lab=GND}
N -260 -420 -260 -370 {
lab=GND}
N 190 -420 190 -370 {
lab=GND}
N 610 -420 610 -370 {
lab=GND}
N 1060 -420 1060 -370 {
lab=GND}
N -2670 -450 -2670 -370 {
lab=#net19}
N 860 -450 860 -370 {
lab=#net19}
N 410 -450 410 -370 {
lab=#net19}
N -10 -450 -10 -370 {
lab=#net19}
N -460 -450 -460 -370 {
lab=#net19}
N -900 -450 -900 -370 {
lab=#net19}
N -1320 -450 -1320 -370 {
lab=#net19}
N -1770 -450 -1770 -370 {
lab=#net19}
N -2220 -450 -2220 -370 {
lab=#net19}
N -2570 30 -2570 50 {
lab=comp_m}
N 960 30 1270 30 {
lab=comp_m}
N 960 30 960 50 {
lab=comp_m}
N 510 30 510 50 {
lab=comp_m}
N 90 30 90 50 {
lab=comp_m}
N -360 30 -360 50 {
lab=comp_m}
N -800 30 -800 50 {
lab=comp_m}
N -1220 30 -1220 50 {
lab=comp_m}
N -1670 30 -1670 50 {
lab=comp_m}
N -2120 30 -2120 50 {
lab=comp_m}
N -2470 240 -2470 280 {
lab=GND}
N 1060 280 1120 280 {
lab=GND}
N 610 240 610 280 {
lab=GND}
N 190 240 190 280 {
lab=GND}
N -260 240 -260 280 {
lab=GND}
N -700 240 -700 280 {
lab=GND}
N -1120 240 -1120 280 {
lab=GND}
N -1570 240 -1570 280 {
lab=GND}
N -2020 240 -2020 280 {
lab=GND}
N -2670 240 -2670 310 {
lab=#net18}
N 410 240 410 310 {
lab=#net18}
N -10 240 -10 310 {
lab=#net18}
N -460 240 -460 310 {
lab=#net18}
N -900 240 -900 310 {
lab=#net18}
N -1320 240 -1320 310 {
lab=#net18}
N -1770 240 -1770 310 {
lab=#net18}
N -2220 240 -2220 310 {
lab=#net18}
N -2970 -160 -2570 -160 {
lab=comp_p}
N -3010 -450 -2670 -450 {
lab=#net19}
N -3040 -550 -3010 -550 {
lab=#net19}
N -3010 -550 -3010 -450 {
lab=#net19}
N -3040 410 -3010 410 {
lab=#net18}
N -3010 310 -3010 410 {
lab=#net18}
N -3010 310 -2670 310 {
lab=#net18}
N -3040 210 -3010 210 {
lab=#net18}
N -3010 210 -3010 310 {
lab=#net18}
N -2970 30 -2570 30 {
lab=comp_m}
N 1270 -160 1270 -90 {
lab=comp_p}
N 1270 -50 1270 30 {
lab=comp_m}
N -3170 210 -3100 210 {
lab=vinm}
N -3010 -450 -3010 -350 {
lab=#net19}
N 960 -160 1270 -160 {
lab=comp_p}
N -2670 -280 -2570 -280 {
lab=#net8}
N -2570 -280 -2570 -240 {
lab=#net8}
N -3040 -350 -3010 -350 {
lab=#net19}
N -3150 -350 -3100 -350 {
lab=vinp}
N -2570 -280 -2470 -280 {
lab=#net8}
N -2670 -450 -2220 -450 {
lab=#net19}
N -2220 -450 -1770 -450 {
lab=#net19}
N -1770 -450 -1320 -450 {
lab=#net19}
N -1320 -450 -900 -450 {
lab=#net19}
N -900 -450 -460 -450 {
lab=#net19}
N -460 -450 -10 -450 {
lab=#net19}
N -10 -450 410 -450 {
lab=#net19}
N -2220 310 -1770 310 {
lab=#net18}
N -1770 310 -1320 310 {
lab=#net18}
N -1320 310 -900 310 {
lab=#net18}
N -900 310 -460 310 {
lab=#net18}
N -460 310 -10 310 {
lab=#net18}
N -10 310 410 310 {
lab=#net18}
N 410 310 860 310 {
lab=#net18}
N -2570 -160 -2120 -160 {
lab=comp_p}
N -2670 310 -2220 310 {
lab=#net18}
N 1270 -90 1380 -90 {
lab=comp_p}
N 1270 -50 1380 -50 {
lab=comp_m}
N 410 -450 860 -450 {
lab=#net19}
N 1500 -70 1520 -70 {
lab=#net20}
N -430 710 -430 720 {
lab=GND}
N -490 590 -490 610 {
lab=vcm}
N -430 610 -370 610 {
lab=vcm}
N -370 590 -370 610 {
lab=vcm}
N -430 610 -430 650 {
lab=vcm}
N -3390 -970 -3380 -970 {
lab=#net21}
N -3300 -970 -3290 -970 {
lab=#net22}
N -2920 -970 -2780 -970 {
lab=smpl_d6}
N -3100 -1140 -3090 -1140 {
lab=#net23}
N -3010 -1140 -3000 -1140 {
lab=#net24}
N -2920 -1140 -2910 -1140 {
lab=#net25}
N -2830 -1140 -2820 -1140 {
lab=#net26}
N -2740 -1140 -2730 -1140 {
lab=#net27}
N -2650 -1140 -2630 -1140 {
lab=smpl_n_d6}
N -3030 600 -3020 600 {
lab=#net28}
N -2940 600 -2930 600 {
lab=#net29}
N -2760 680 -2750 680 {
lab=#net30}
N -2670 680 -2660 680 {
lab=#net31}
N -2500 680 -2490 680 {
lab=#net32}
N -2410 680 -2400 680 {
lab=#net33}
N -2320 680 -2310 680 {
lab=#net34}
N -3030 680 -3020 680 {
lab=#net35}
N -2940 680 -2930 680 {
lab=#net36}
N -2850 680 -2840 680 {
lab=#net37}
N -2550 -1140 -2540 -1140 {
lab=#net38}
N -2460 -1140 -2450 -1140 {
lab=#net39}
N -2370 -1140 -2360 -1140 {
lab=#net40}
N -2280 -1140 -2270 -1140 {
lab=#net41}
N -2190 -1140 -2180 -1140 {
lab=smpl_n_d12}
N 510 -160 960 -160 {
lab=comp_p}
N 90 -160 510 -160 {
lab=comp_p}
N -360 -160 90 -160 {
lab=comp_p}
N -800 -160 -360 -160 {
lab=comp_p}
N -1220 -160 -800 -160 {
lab=comp_p}
N -1670 -160 -1220 -160 {
lab=comp_p}
N -2120 -160 -1670 -160 {
lab=comp_p}
N -2470 -420 -2020 -420 {
lab=GND}
N -2020 -420 -1570 -420 {
lab=GND}
N -1570 -420 -1120 -420 {
lab=GND}
N -1120 -420 -700 -420 {
lab=GND}
N -700 -420 -260 -420 {
lab=GND}
N -260 -420 190 -420 {
lab=GND}
N 190 -420 610 -420 {
lab=GND}
N 610 -420 1060 -420 {
lab=GND}
N 510 30 960 30 {
lab=comp_m}
N 90 30 510 30 {
lab=comp_m}
N -360 30 90 30 {
lab=comp_m}
N -800 30 -360 30 {
lab=comp_m}
N -1220 30 -800 30 {
lab=comp_m}
N -1670 30 -1220 30 {
lab=comp_m}
N -2120 30 -1670 30 {
lab=comp_m}
N -2570 30 -2120 30 {
lab=comp_m}
N 610 280 1060 280 {
lab=GND}
N 190 280 610 280 {
lab=GND}
N -260 280 190 280 {
lab=GND}
N -700 280 -260 280 {
lab=GND}
N -1120 280 -700 280 {
lab=GND}
N -1570 280 -1120 280 {
lab=GND}
N -2020 280 -1570 280 {
lab=GND}
N -2470 280 -2020 280 {
lab=GND}
N -490 610 -430 610 {
lab=vcm}
N 860 310 960 310 {
lab=#net18}
N -3210 -970 -3200 -970 {
lab=#net42}
N -3120 -970 -3110 -970 {
lab=#net43}
N -2940 -970 -2920 -970 {
lab=smpl_d6}
N -3030 -970 -3020 -970 {
lab=#net44}
N -2660 -950 -2310 -950 {
lab=#net45}
N -2470 -950 -2470 -930 {
lab=#net45}
N -2470 -850 -2470 -810 {
lab=#net46}
N -2470 -810 -2310 -810 {
lab=#net46}
N -2110 -710 -2100 -710 {
lab=#net21}
N -2020 -710 -2010 -710 {
lab=#net22}
N -1930 -710 -1920 -710 {
lab=#net23}
N -1840 -710 -1830 -710 {
lab=#net24}
N -1750 -710 -1740 -710 {
lab=#net25}
N -1660 -710 -1640 -710 {
lab=smpl_n_d6}
N -1560 -710 -1550 -710 {
lab=#net26}
N -1470 -710 -1460 -710 {
lab=#net27}
N -1380 -710 -1370 -710 {
lab=#net28}
N -1290 -710 -1280 -710 {
lab=#net29}
N -1200 -710 -1190 -710 {
lab=#net30}
C {sky130_fd_pr/cap_mim_m3_1.sym} 510 -210 2 0 {name=C1 model=cap_mim_m3_1 W=15 L=15 MF=1 spiceprefix=X}
C {switch_ngspice.sym} 610 -340 2 0 {name=S2 model=SWITCH1}
C {switch_ngspice.sym} 410 -340 2 0 {name=S1 model=SWITCH1}
C {lab_pin.sym} 450 -340 2 0 {name=p2 sig_type=std_logic lab=dx0}
C {lab_pin.sym} 650 -340 2 0 {name=p3 sig_type=std_logic lab=dnx0}
C {sky130_fd_pr/cap_mim_m3_1.sym} 90 -210 2 0 {name=C2 model=cap_mim_m3_1 W=15 L=15 MF=2 spiceprefix=X}
C {switch_ngspice.sym} 190 -340 2 0 {name=S3 model=SWITCH1}
C {switch_ngspice.sym} -10 -340 2 0 {name=S4 model=SWITCH1}
C {lab_pin.sym} 30 -340 2 0 {name=p7 sig_type=std_logic lab=dx1}
C {lab_pin.sym} 230 -340 2 0 {name=p8 sig_type=std_logic lab=dnx1}
C {sky130_fd_pr/cap_mim_m3_1.sym} -360 -210 2 0 {name=C3 model=cap_mim_m3_1 W=15 L=15 MF=4 spiceprefix=X}
C {switch_ngspice.sym} -260 -340 2 0 {name=S5 model=SWITCH1}
C {switch_ngspice.sym} -460 -340 2 0 {name=S6 model=SWITCH1}
C {lab_pin.sym} -420 -340 2 0 {name=p11 sig_type=std_logic lab=dx2}
C {lab_pin.sym} -220 -340 2 0 {name=p12 sig_type=std_logic lab=dnx2}
C {sky130_fd_pr/cap_mim_m3_1.sym} -800 -210 2 0 {name=C4 model=cap_mim_m3_1 W=15 L=15 MF=8 spiceprefix=X}
C {switch_ngspice.sym} -700 -340 2 0 {name=S7 model=SWITCH1}
C {switch_ngspice.sym} -900 -340 2 0 {name=S8 model=SWITCH1}
C {lab_pin.sym} -860 -340 2 0 {name=p15 sig_type=std_logic lab=dx3}
C {lab_pin.sym} -660 -340 2 0 {name=p16 sig_type=std_logic lab=dnx3}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1220 -210 2 0 {name=C5 model=cap_mim_m3_1 W=15 L=15 MF=16 spiceprefix=X}
C {switch_ngspice.sym} -1120 -340 2 0 {name=S9 model=SWITCH1}
C {switch_ngspice.sym} -1320 -340 2 0 {name=S10 model=SWITCH1}
C {lab_pin.sym} -1280 -340 2 0 {name=p19 sig_type=std_logic lab=dx4}
C {lab_pin.sym} -1080 -340 2 0 {name=p20 sig_type=std_logic lab=dnx4}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1670 -210 2 0 {name=C6 model=cap_mim_m3_1 W=15 L=15 MF=32 spiceprefix=X}
C {switch_ngspice.sym} -1570 -340 2 0 {name=S11 model=SWITCH1}
C {switch_ngspice.sym} -1770 -340 2 0 {name=S12 model=SWITCH1}
C {lab_pin.sym} -1730 -340 2 0 {name=p23 sig_type=std_logic lab=dx5}
C {lab_pin.sym} -1530 -340 2 0 {name=p24 sig_type=std_logic lab=dnx5}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2120 -210 2 0 {name=C7 model=cap_mim_m3_1 W=15 L=15 MF=64 spiceprefix=X}
C {switch_ngspice.sym} -2020 -340 2 0 {name=S13 model=SWITCH1}
C {switch_ngspice.sym} -2220 -340 2 0 {name=S14 model=SWITCH1}
C {lab_pin.sym} -2180 -340 2 0 {name=p27 sig_type=std_logic lab=dx6}
C {lab_pin.sym} -1980 -340 2 0 {name=p28 sig_type=std_logic lab=dnx6}
C {switch_ngspice.sym} -2470 -340 2 0 {name=S15 model=SWITCH1}
C {switch_ngspice.sym} -2670 -340 2 0 {name=S16 model=SWITCH1}
C {lab_pin.sym} -2630 -340 2 0 {name=p31 sig_type=std_logic lab=dx7}
C {lab_pin.sym} -2430 -340 2 0 {name=p32 sig_type=std_logic lab=dnx7}
C {sky130_fd_pr/cap_mim_m3_1.sym} 960 -210 2 0 {name=C9 model=cap_mim_m3_1 W=15 L=15 MF=1 spiceprefix=X}
C {switch_ngspice.sym} 1060 -340 2 0 {name=S17 model=SWITCH1}
C {switch_ngspice.sym} 860 -340 2 0 {name=S18 model=SWITCH1}
C {lab_pin.sym} 900 -340 2 0 {name=p35 sig_type=std_logic lab=smpl}
C {lab_pin.sym} 1100 -340 2 0 {name=p36 sig_type=std_logic lab=smpl_n}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2570 80 0 1 {name=C10 model=cap_mim_m3_1 W=15 L=15 MF=128 spiceprefix=X}
C {switch_ngspice.sym} -2470 210 0 1 {name=S19 model=SWITCH1}
C {switch_ngspice.sym} -2670 210 0 1 {name=S20 model=SWITCH1}
C {lab_pin.sym} -2630 210 0 1 {name=p39 sig_type=std_logic lab=d_n_d37}
C {lab_pin.sym} -2430 210 0 1 {name=p40 sig_type=std_logic lab=d_d77}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2120 80 0 1 {name=C11 model=cap_mim_m3_1 W=15 L=15 MF=64 spiceprefix=X}
C {switch_ngspice.sym} -2020 210 0 1 {name=S21 model=SWITCH1}
C {switch_ngspice.sym} -2220 210 0 1 {name=S22 model=SWITCH1}
C {lab_pin.sym} -2180 210 0 1 {name=p43 sig_type=std_logic lab=d_n_d36}
C {lab_pin.sym} -1980 210 0 1 {name=p44 sig_type=std_logic lab=d_d76}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1670 80 0 1 {name=C12 model=cap_mim_m3_1 W=15 L=15 MF=32 spiceprefix=X}
C {switch_ngspice.sym} -1570 210 0 1 {name=S23 model=SWITCH1}
C {switch_ngspice.sym} -1770 210 0 1 {name=S24 model=SWITCH1}
C {lab_pin.sym} -1730 210 0 1 {name=p47 sig_type=std_logic lab=d_n_d35}
C {lab_pin.sym} -1530 210 0 1 {name=p48 sig_type=std_logic lab=d_d75}
C {sky130_fd_pr/cap_mim_m3_1.sym} -1220 80 0 1 {name=C13 model=cap_mim_m3_1 W=15 L=15 MF=16 spiceprefix=X}
C {switch_ngspice.sym} -1120 210 0 1 {name=S25 model=SWITCH1}
C {switch_ngspice.sym} -1320 210 0 1 {name=S26 model=SWITCH1}
C {lab_pin.sym} -1280 210 0 1 {name=p51 sig_type=std_logic lab=d_n_d34}
C {lab_pin.sym} -1080 210 0 1 {name=p52 sig_type=std_logic lab=d_d74}
C {sky130_fd_pr/cap_mim_m3_1.sym} -800 80 0 1 {name=C14 model=cap_mim_m3_1 W=15 L=15 MF=8 spiceprefix=X}
C {switch_ngspice.sym} -700 210 0 1 {name=S27 model=SWITCH1}
C {switch_ngspice.sym} -900 210 0 1 {name=S28 model=SWITCH1}
C {lab_pin.sym} -860 210 0 1 {name=p55 sig_type=std_logic lab=d_n_d33}
C {lab_pin.sym} -660 210 0 1 {name=p56 sig_type=std_logic lab=d_d73}
C {sky130_fd_pr/cap_mim_m3_1.sym} -360 80 0 1 {name=C15 model=cap_mim_m3_1 W=15 L=15 MF=4 spiceprefix=X}
C {switch_ngspice.sym} -260 210 0 1 {name=S29 model=SWITCH1}
C {switch_ngspice.sym} -460 210 0 1 {name=S30 model=SWITCH1}
C {lab_pin.sym} -420 210 0 1 {name=p59 sig_type=std_logic lab=d_n_d32}
C {lab_pin.sym} -220 210 0 1 {name=p60 sig_type=std_logic lab=d_d72}
C {sky130_fd_pr/cap_mim_m3_1.sym} 90 80 0 1 {name=C16 model=cap_mim_m3_1 W=15 L=15 MF=2 spiceprefix=X}
C {switch_ngspice.sym} 190 210 0 1 {name=S31 model=SWITCH1}
C {switch_ngspice.sym} -10 210 0 1 {name=S32 model=SWITCH1}
C {lab_pin.sym} 30 210 0 1 {name=p63 sig_type=std_logic lab=d_n_d31}
C {lab_pin.sym} 230 210 0 1 {name=p64 sig_type=std_logic lab=d_d71}
C {sky130_fd_pr/cap_mim_m3_1.sym} 510 80 0 1 {name=C17 model=cap_mim_m3_1 W=15 L=15 MF=1 spiceprefix=X}
C {switch_ngspice.sym} 610 210 0 1 {name=S33 model=SWITCH1}
C {switch_ngspice.sym} 410 210 0 1 {name=S34 model=SWITCH1}
C {lab_pin.sym} 450 210 0 1 {name=p67 sig_type=std_logic lab=d_n_d30}
C {lab_pin.sym} 650 210 0 1 {name=p68 sig_type=std_logic lab=d_d70}
C {sky130_fd_pr/cap_mim_m3_1.sym} 960 80 0 1 {name=C18 model=cap_mim_m3_1 W=15 L=15 MF=1 spiceprefix=X}
C {switch_ngspice.sym} -3070 -550 1 0 {name=S37 model=SWITCH1}
C {lab_pin.sym} -3070 -590 1 0 {name=p76 sig_type=std_logic lab=smpl_n_d6}
C {switch_ngspice.sym} -3070 210 1 0 {name=S39 model=SWITCH1}
C {switch_ngspice.sym} -3070 410 1 0 {name=S40 model=SWITCH1}
C {lab_pin.sym} -3070 370 1 0 {name=p79 sig_type=std_logic lab=smpl_n_d12}
C {lab_pin.sym} -3070 170 1 0 {name=p80 sig_type=std_logic lab=smpl}
C {switch_ngspice.sym} -3000 -160 1 0 {name=S41 model=SWITCH1}
C {lab_pin.sym} -3000 -200 1 0 {name=p82 sig_type=std_logic lab=smpl}
C {switch_ngspice.sym} -3000 30 1 0 {name=S42 model=SWITCH1}
C {lab_pin.sym} -3000 -10 1 0 {name=p84 sig_type=std_logic lab=smpl
}
C {lab_pin.sym} -3030 -160 0 0 {name=p85 sig_type=std_logic lab=vcm}
C {lab_pin.sym} -3030 30 0 0 {name=p86 sig_type=std_logic lab=vcm}
C {lab_pin.sym} -3100 -550 0 0 {name=p87 sig_type=std_logic lab=vref}
C {lab_pin.sym} -3100 410 0 0 {name=p88 sig_type=std_logic lab=vref}
C {lab_pin.sym} -3150 -350 0 0 {name=p90 sig_type=std_logic lab=vinp}
C {vsource.sym} 500 620 0 0 {name=Vdd8 value="pulse(1.8 0 1n 1n 1n 50n 100u 1)" savecurrent=false}
C {gnd.sym} 500 650 0 0 {name=l6 lab=GND}
C {vsource.sym} 290 620 0 0 {name=Vdd4 value="pulse(0 1.8 1n 1n 1n 500n 1u)" savecurrent=false}
C {gnd.sym} 290 650 0 0 {name=l7 lab=GND}
C {lab_pin.sym} 290 590 1 0 {name=p98 sig_type=std_logic lab=clk}
C {lab_pin.sym} 500 590 1 0 {name=p99 sig_type=std_logic lab=rst_n}
C {devices/code.sym} -3060 -1400 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/code_shown.sym} -2900 -1560 0 0 {name=STIMULI
only_toplevel=true
value="
.tran 10n 40u
.save all
.param vcc = 1.8
.param vdd = 1.8
.param vdiff = 500m
vvcc vcc 0 dc vcc
vvdd vdd 0 dc vdd
vvss vss 0 0
.control

run
plot comp_p comp_m
plot d0+2 d1+4 d2+6 d3+8 d4+10 d5+12 d6+14 d7+16 data_rdy+18
write sar_tb.raw comp_p comp_m
set wr_singlescale
set wr_vecnames
wrdata sar.txt comp_p comp_m
.endc
"}
C {code.sym} -3200 -1400 0 0 {name=SWITCH1 only_toplevel=false value=".model SWITCH1 sw vt=0.9 vh=0 ron=1 roff =100G"}
C {gnd.sym} 1120 -420 0 0 {name=l2 lab=GND}
C {sky130_stdcells/or2_1.sym} -2720 -950 0 0 {name=x4[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -3470 -970 0 0 {name=p103 sig_type=std_logic lab=smpl}
C {lab_pin.sym} -2780 -930 0 0 {name=p104 sig_type=std_logic lab=d[7..0]}
C {lab_pin.sym} -2630 -990 2 0 {name=p105 sig_type=std_logic lab=dx[7..0]}
C {vsource.sym} 50 620 0 0 {name=Vdd1 value=1.8 savecurrent=false}
C {gnd.sym} 50 650 0 0 {name=l3 lab=GND}
C {lab_pin.sym} 50 590 1 0 {name=p107 sig_type=std_logic lab=vref}
C {lab_pin.sym} 1270 -160 0 1 {name=p111 sig_type=std_logic lab=comp_p}
C {lab_pin.sym} 1270 30 0 1 {name=p112 sig_type=std_logic lab=comp_m}
C {lab_pin.sym} -3070 -390 3 1 {name=p135 sig_type=std_logic lab=smpl}
C {switch_ngspice.sym} -3070 -350 1 0 {name=S38 model=SWITCH1}
C {lab_pin.sym} -2780 -760 0 0 {name=p75 sig_type=std_logic lab=d_n[7..0]}
C {lab_pin.sym} -2660 -780 2 0 {name=p136 sig_type=std_logic lab=dnx[7..0]}
C {sky130_stdcells/and2_0.sym} -2720 -780 0 0 {name=x12[7:0] VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2780 -800 0 0 {name=p73 sig_type=std_logic lab=smpl_n_d6}
C {sky130_fd_pr/cap_mim_m3_1.sym} -2570 -210 2 0 {name=C8 model=cap_mim_m3_1 W=15 L=15 MF=128 spiceprefix=X}
C {/foss/designs/Behavioural module/Behavioural module/comp_behavioral.sym} 1420 -70 0 0 {name=x1 OFFSET=0.9 AMPLITUDE=1.8 GAIN=100000 ROUT=00 COUT=0}
C {sky130_stdcells/inv_8.sym} 1560 -70 0 0 {name=x3 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} 1600 -70 2 0 {name=p110 sig_type=std_logic lab=comp_out}
C {gnd.sym} 1120 280 0 0 {name=l1 lab=GND}
C {lab_pin.sym} -3170 210 0 0 {name=p89 sig_type=std_logic lab=vinm}
C {gnd.sym} -2630 -360 3 0 {name=l9 lab=GND
value=0.6}
C {gnd.sym} -2430 -360 3 0 {name=l20 lab=GND
value=0.6}
C {gnd.sym} -2180 -360 3 0 {name=l22 lab=GND
value=0.6}
C {gnd.sym} -1980 -360 3 0 {name=l23 lab=GND
value=0.6}
C {gnd.sym} -1730 -360 3 0 {name=l24 lab=GND
value=0.6}
C {gnd.sym} -1530 -360 3 0 {name=l25 lab=GND
value=0.6}
C {gnd.sym} -1280 -360 3 0 {name=l26 lab=GND
value=0.6}
C {gnd.sym} -1080 -360 3 0 {name=l27 lab=GND
value=0.6}
C {gnd.sym} -860 -360 3 0 {name=l28 lab=GND
value=0.6}
C {gnd.sym} -660 -360 3 0 {name=l29 lab=GND
value=0.6}
C {gnd.sym} -420 -360 3 0 {name=l30 lab=GND
value=0.6}
C {gnd.sym} -220 -360 3 0 {name=l31 lab=GND
value=0.6}
C {gnd.sym} 30 -360 3 0 {name=l32 lab=GND
value=0.6}
C {gnd.sym} 230 -360 3 0 {name=l33 lab=GND
value=0.6}
C {gnd.sym} 450 -360 3 0 {name=l34 lab=GND
value=0.6}
C {gnd.sym} 650 -360 3 0 {name=l35 lab=GND
value=0.6}
C {gnd.sym} 900 -360 3 0 {name=l36 lab=GND
value=0.6}
C {gnd.sym} 1100 -360 3 0 {name=l37 lab=GND
value=0.6}
C {gnd.sym} 650 230 3 0 {name=l40 lab=GND
value=0.6}
C {gnd.sym} 450 230 3 0 {name=l41 lab=GND
value=0.6}
C {gnd.sym} 230 230 3 0 {name=l42 lab=GND
value=0.6}
C {gnd.sym} 30 230 3 0 {name=l43 lab=GND
value=0.6}
C {gnd.sym} -220 230 3 0 {name=l44 lab=GND
value=0.6}
C {gnd.sym} -420 230 3 0 {name=l45 lab=GND
value=0.6}
C {gnd.sym} -660 230 3 0 {name=l46 lab=GND
value=0.6}
C {gnd.sym} -860 230 3 0 {name=l47 lab=GND
value=0.6}
C {gnd.sym} -1080 230 3 0 {name=l48 lab=GND
value=0.6}
C {gnd.sym} -1280 230 3 0 {name=l49 lab=GND
value=0.6}
C {gnd.sym} -1530 230 3 0 {name=l50 lab=GND
value=0.6}
C {gnd.sym} -1730 230 3 0 {name=l51 lab=GND
value=0.6}
C {gnd.sym} -1980 230 3 0 {name=l52 lab=GND
value=0.6}
C {gnd.sym} -2180 230 3 0 {name=l53 lab=GND
value=0.6}
C {gnd.sym} -2430 230 3 0 {name=l54 lab=GND
value=0.6}
C {gnd.sym} -2630 230 3 0 {name=l55 lab=GND
value=0.6}
C {gnd.sym} -3090 -590 2 0 {name=l56 lab=GND
value=0.6}
C {gnd.sym} -3090 -390 2 0 {name=l57 lab=GND
value=0.6}
C {gnd.sym} -3020 -200 2 0 {name=l58 lab=GND
value=0.6}
C {gnd.sym} -3020 -10 2 0 {name=l59 lab=GND
value=0.6}
C {gnd.sym} -3090 170 2 0 {name=l60 lab=GND
value=0.6}
C {gnd.sym} -3090 370 2 0 {name=l61 lab=GND
value=0.6}
C {/foss/designs/test/design/sar_controller.sym} -20 850 0 0 {name=x2}
C {lab_pin.sym} -170 790 0 0 {name=p1 sig_type=std_logic lab=clk}
C {lab_pin.sym} -170 810 0 0 {name=p4 sig_type=std_logic lab=rst_n}
C {lab_pin.sym} -170 830 0 0 {name=p5 sig_type=std_logic lab=comp_out}
C {lab_pin.sym} 130 790 2 0 {name=p6 sig_type=std_logic lab=data_rdy}
C {lab_pin.sym} 130 810 2 0 {name=p9 sig_type=std_logic lab=smpl}
C {lab_pin.sym} 130 830 2 0 {name=p10 sig_type=std_logic lab=smpl_n}
C {lab_pin.sym} 130 870 2 0 {name=p13 sig_type=std_logic lab=supply}
C {lab_pin.sym} 130 890 2 0 {name=p14 sig_type=std_logic lab=d[7..0]}
C {lab_pin.sym} 130 910 2 0 {name=p17 sig_type=std_logic lab=d_n[7..0]}
C {gnd.sym} 130 850 3 0 {name=l18 lab=GND}
C {vsource.sym} -40 620 0 0 {name=Vdd5 value=1.8 savecurrent=false}
C {gnd.sym} -40 650 0 0 {name=l19 lab=GND}
C {lab_pin.sym} -40 590 1 0 {name=p18 sig_type=std_logic lab=supply}
C {devices/vsource.sym} -430 680 0 0 {name=V_VCM_2 value=0.9}
C {devices/gnd.sym} -430 720 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -430 640 0 0 {name=l11 sig_type=std_logic lab=vcm}
C {devices/vsource.sym} -490 560 0 0 {name=V_VCM_1 value=\{vdiff/2\}}
C {devices/vsource.sym} -370 560 2 1 {name=V_VCM_3 value=\{vdiff/2\}}
C {lab_pin.sym} -370 530 1 0 {name=p21 sig_type=std_logic lab=vinm}
C {lab_pin.sym} -490 530 1 0 {name=p22 sig_type=std_logic lab=vinp}
C {sky130_stdcells/buf_1.sym} -3430 -970 0 0 {name=x4 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3340 -970 0 0 {name=x5 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3250 -970 0 0 {name=x6 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -3180 -1140 0 0 {name=p25 sig_type=std_logic lab=smpl_n}
C {sky130_stdcells/buf_1.sym} -3140 -1140 0 0 {name=x7 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3050 -1140 0 0 {name=x8 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2960 -1140 0 0 {name=x9 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2850 -970 1 0 {name=p26 sig_type=std_logic lab=smpl_d6}
C {sky130_stdcells/buf_1.sym} -2870 -1140 0 0 {name=x10 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2780 -1140 0 0 {name=x11 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2690 -1140 0 0 {name=x12 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2640 -1140 3 0 {name=p29 sig_type=std_logic lab=smpl_n_d6}
C {lab_pin.sym} -3110 600 0 0 {name=p30 sig_type=std_logic lab=d_n[7..0]}
C {sky130_stdcells/buf_1.sym} -3070 600 0 0 {name=x13[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2980 600 0 0 {name=x14[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2890 600 0 0 {name=x15[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2850 600 2 0 {name=p33 sig_type=std_logic lab=d_n_d3[7..0]}
C {sky130_stdcells/buf_1.sym} -2800 680 0 0 {name=x1[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2710 680 0 0 {name=x2[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2620 680 0 0 {name=x3[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2230 680 2 0 {name=p37 sig_type=std_logic lab=d_d7[7..0]}
C {sky130_stdcells/buf_1.sym} -2540 680 0 0 {name=x5[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2450 680 0 0 {name=x6[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2360 680 0 0 {name=x7[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2270 680 0 0 {name=x8[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -3110 680 0 0 {name=p38 sig_type=std_logic lab=d[7..0]}
C {sky130_stdcells/buf_1.sym} -3070 680 0 0 {name=x9[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2980 680 0 0 {name=x10[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2890 680 0 0 {name=x11[7:0] VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2590 -1140 0 0 {name=x13 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2500 -1140 0 0 {name=x14 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2410 -1140 0 0 {name=x15 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2320 -1140 0 0 {name=x16 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2230 -1140 0 0 {name=x17 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2180 -1140 2 0 {name=p34 sig_type=std_logic lab=smpl_n_d12}
C {sky130_stdcells/buf_1.sym} -3160 -970 0 0 {name=x18 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -3070 -970 0 0 {name=x19 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2980 -970 0 0 {name=x20 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_8.sym} -2470 -890 1 0 {name=x21 VGND=vss VNB=vss VPB=vcc VPWR=vcc prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/nor2_1.sym} -2250 -930 0 0 {name=x22 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -2190 -710 0 0 {name=p41 sig_type=std_logic lab=smpl_n}
C {sky130_stdcells/buf_1.sym} -2150 -710 0 0 {name=x23 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -2060 -710 0 0 {name=x24 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -1970 -710 0 0 {name=x25 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -1880 -710 0 0 {name=x26 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -1790 -710 0 0 {name=x27 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -1700 -710 0 0 {name=x28 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} -1650 -710 3 0 {name=p42 sig_type=std_logic lab=smpl_n_d6}
C {sky130_stdcells/buf_1.sym} -1600 -710 0 0 {name=x29 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -1510 -710 0 0 {name=x30 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -1420 -710 0 0 {name=x31 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -1330 -710 0 0 {name=x32 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} -1240 -710 0 0 {name=x33 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
