v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/test/design/adc_comp.sym} 0 -10 0 0 {name=x1}
